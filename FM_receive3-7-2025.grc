options:
  parameters:
    generate_options: qt_gui
    id: nbfm_rcvr
    output_language: python
    run: 'False'
    title: SDuongR
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: '8'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rf_decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    label: Squelch
    start: '-100'
    step: '5'
    stop: '0'
    value: '-50'
  states: {}
- name: tuning
  id: variable_qtgui_chooser
  parameters:
    label: station
    label0: 'VOV1: 94.0 MHz'
    label1: 'VOV3: 102.7 MHz'
    label2: 'Giao thong: 91.0 MHz'
    label3: 'VOH: 99.9 MHz'
    num_opts: '4'
    option0: '94000000'
    option1: '102700000'
    option2: '91000000'
    option3: '99900000'
    type: int
    value: '94000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.3'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: audio_decim
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: samp_rate/rf_decim
    deviation: deviation
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw:CARD=AudioPCI,DEV=0
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: float
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '500000'
    bbdc: 'True'
    buffer_size: '0x4000'
    filter_source: '''Auto'''
    frequency: tuning
    gain1: '''fast_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: usb:2.4.5
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '5'
    type: ccc
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_fm_demod_cf_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_simple_squelch_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
