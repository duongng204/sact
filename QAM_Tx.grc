options:
  parameters:
    author: duong
    generate_options: qt_gui
    id: QAM_Tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: carrier_freq
  id: variable
  parameters:
    value: '850000000'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: mod_order
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '32'
  states: {}
- name: variable_1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[1, -1, 1, -1]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[1,1,-1,-1]'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: '[9.446010153624229e-06,9.157650310953613e-06,8.865617928677239e-06,8.570017598685808e-06,8.270954822364729e-06,7.968534191604704e-06,7.662864845769946e-06,7.35405728846672e-06,7.042220204311889e-06,6.727465915901121e-06,6.409906291082734e-06,6.089655471441802e-06,5.7668275985633954e-06,5.441539087769343e-06,5.11390635438147e-06,4.784047177963657e-06,4.452080247574486e-06,4.118124707019888e-06,3.782300836974173e-06,3.4447296002326766e-06,3.1055326417117612e-06,2.7648325158224907e-06,2.4227522317232797e-06,2.0794154806935694e-06,1.734946295073314e-06,1.3894696166971698e-06,1.0431108421471436e-06,6.959954816920799e-07,3.4824967087843106e-07,-3.9120615266597535e-20,-3.4862677011915366e-07,-6.97503594437876e-07,-1.0465030300110811e-06,-1.395497633893683e-06,-1.7443597926103394e-06,-2.0929614947817754e-06,-2.441174956402392e-06,-2.7888727345271036e-06,-3.1359263630292844e-06,-3.4822080579033354e-06,-3.827590717264684e-06,-4.1719458749867044e-06,-4.515146883932175e-06,-4.857066869590199e-06,-5.197578502702527e-06,-5.536554908758262e-06,-5.873870122741209e-06,-6.209399543877225e-06,-6.543015842908062e-06,-6.874595783301629e-06,-7.204014309536433e-06,-7.531148185080383e-06,-7.85587417340139e-06,-8.178069947462063e-06,-8.497612725477666e-06,-8.814383363642264e-06,-9.128260899160523e-06,-9.439125278731808e-06,-9.74685917753959e-06,-1.0051345270767342e-05,-1.035246441460913e-05,-1.0650102922227234e-05,-1.0944148016278632e-05,-1.1234482371946797e-05,-1.1520996849867515e-05,-1.1803578672697768e-05,-1.208211779157864e-05,-1.235650597664062e-05,-1.26266368170036e-05,-1.2892402082798071e-05,-1.315369809162803e-05,-1.3410420251602773e-05,-1.3662468518305104e-05,-1.3909741937823128e-05,-1.4152139556244947e-05,-1.4389566786121577e-05,-1.4621925402025227e-05,-1.4849123544991016e-05,-1.507106571807526e-05,-1.5287663700291887e-05,-1.5498824723181315e-05,-1.570446511323098e-05,-1.590449937793892e-05,-1.6098838386824355e-05,-1.6287407561321743e-05,-1.6470121408929117e-05,-1.6646903532091528e-05,-1.681767935224343e-05,-1.6982372471829876e-05,-1.7140911950264126e-05,-1.729322502797004e-05,-1.7439244402339682e-05,-1.7578906408743933e-05,-1.7712145563564263e-05,-1.7838900021160953e-05,-1.7959111573873088e-05,-1.807272019505035e-05,-1.8179674952989444e-05,-1.8279914002050646e-05,-1.837339914345648e-05,-1.846007398853544e-05,-1.8539891243563034e-05,-1.861281634774059e-05,-1.867879655037541e-05,-1.873780092864763e-05,-1.8789789464790374e-05,-1.8834727598004974e-05,-1.8872588043450378e-05,-1.8903334421338513e-05,-1.8926946722785942e-05,-1.894339766295161e-05,-1.8952663594973274e-05,-1.8954728147946298e-05,-1.8949574950966053e-05,-1.893718945211731e-05,-1.891755709948484e-05,-1.8890670617111027e-05,-1.8856524548027664e-05,-1.8815111616277136e-05,-1.8766437278827652e-05,-1.8710496078711003e-05,-1.8647291653905995e-05,-1.8576836737338454e-05,-1.8499134966987185e-05,-1.841420089476742e-05,-1.832204725360498e-05,-1.8222688595415093e-05,-1.8116152205038816e-05,-1.800245081540197e-05,-1.788161534932442e-05,-1.775367127265781e-05,-1.7618649508222006e-05,-1.7476582797826268e-05,-1.7327505702269264e-05,-1.7171456420328468e-05,-1.700847496977076e-05,-1.683860318735242e-05,-1.666188836679794e-05,-1.647838143981062e-05,-1.6288127881125547e-05,-1.6091184079414234e-05,-1.5887608242337592e-05,-1.567745493957773e-05,-1.546078419778496e-05,-1.5237666048051324e-05,-1.5008158698037732e-05,-1.4772338545299135e-05,-1.4530270163959358e-05,-1.4282029042078648e-05,-1.4027692486706655e-05,-1.3767337804893032e-05,-1.3501045032171533e-05,-1.3228897842054721e-05,-1.2950983546033967e-05,-1.2667385817621835e-05,-1.2378198334772605e-05,-1.2083512046956457e-05,-1.178341972263297e-05,-1.1478022315714043e-05,-1.1167417142132763e-05,-1.0851702427316923e-05,-1.0530985491641331e-05,-1.0205370017501991e-05,-9.874964234768413e-06,-9.53987728280481e-06,-9.200221029459499e-06,-8.856109161570203e-06,-8.507656275469344e-06,-8.154982424457557e-06,-7.798204933351371e-06,-7.437445219693473e-06,-7.072826520015951e-06,-6.704474344587652e-06,-6.3325142036774196e-06,-5.9570761550276075e-06,-5.578288437391166e-06,-5.196283382247202e-06,-4.811193775822176e-06,-4.4231551328266505e-06,-4.032302967971191e-06,-3.6387752970767906e-06,-3.2427110454591457e-06,-2.84425073004968e-06,-2.4435360046481946e-06,-2.040710114670219e-06,-1.6359169876523083e-06,-1.2293022564335843e-06,-8.210126338781265e-07,-4.1119562865787884e-07,-3.084972356338504e-20,4.124245833736495e-07,8.259274295596697e-07,1.2403571645336342e-06,1.6555612774027395e-06,2.0713866888399934e-06,2.4876796942407964e-06,2.9042853384453338e-06,3.321049007354304e-06,3.737814495252678e-06,4.154425823799102e-06,4.570726105157519e-06,4.986557996744523e-06,5.401764155976707e-06,5.816187240270665e-06,6.229668997548288e-06,6.642050266236765e-06,7.053173703752691e-06,7.462880603270605e-06,7.8710127127124e-06,8.277411325252615e-06,8.68191727931844e-06,9.084374141821172e-06,9.484621841693297e-06,9.882504855340812e-06,1.027786493068561e-05,1.0670544725144282e-05,1.1060386896133423e-05,1.144723682955373e-05,1.1830939001811203e-05,1.2211336979817133e-05,1.2588277968461625e-05,1.2961607353645377e-05,1.3331174159247894e-05,1.3696823771169875e-05,1.4058408851269633e-05,1.441577660443727e-05,1.4768778783036396e-05,1.5117267139430624e-05,1.546109706396237e-05,1.5800120308995247e-05,1.6134192264871672e-05,1.6463172869407572e-05,1.6786918422440067e-05,1.7105288861785084e-05,1.7418145944247954e-05,1.7725355064612813e-05,1.8026772522716783e-05,1.832227462728042e-05,1.8611721316119656e-05,1.889498707896564e-05,1.9171940948581323e-05,1.9442455595708452e-05,1.9706407329067588e-05,1.996367245737929e-05,2.021413092734292e-05,2.045766268565785e-05,2.0694153135991655e-05,2.092348768201191e-05,2.1145549908396788e-05,2.1360236132750288e-05,2.156743357772939e-05,2.176703856093809e-05,2.1958951037959196e-05,2.2143067326396704e-05,2.2319291019812226e-05,2.248752753075678e-05,2.2647682271781377e-05,2.2799666112405248e-05,2.294339174113702e-05,2.3078773665474728e-05,2.320573548786342e-05,2.332418989681173e-05,2.3434069589711726e-05,2.353529453102965e-05,2.362779741815757e-05,2.3711510948487557e-05,2.3786371457390487e-05,2.3852315280237235e-05,2.39092896663351e-05,2.395723458903376e-05,2.399609911662992e-05,2.4025839593377896e-05,2.4046405087574385e-05,2.4057757400441915e-05,2.4059854695224203e-05,2.4052664230111986e-05,2.4036151444306597e-05,2.4010290871956386e-05,2.3975053409230895e-05,2.393042086623609e-05,2.3876373234088533e-05,2.3812895960872993e-05,2.373997813265305e-05,2.365760701650288e-05,2.3565786250401288e-05,2.3464508558390662e-05,2.3353777578449808e-05,2.3233602405525744e-05,2.3103992134565488e-05,2.296495767950546e-05,2.2816517230239697e-05,2.2658690795651637e-05,2.2491505660582334e-05,2.231498365290463e-05,2.2129162971396e-05,2.19340727198869e-05,2.1729756554123014e-05,2.151625267288182e-05,2.1293612007866614e-05,2.1061878214823082e-05,2.0821107682422735e-05,2.0571358618326485e-05,2.0312689230195247e-05,2.0045165001647547e-05,1.9768851416301914e-05,1.948382123373449e-05,1.919015085150022e-05,1.8887914848164655e-05,1.8577196897240356e-05,1.82580879481975e-05,1.793066803656984e-05,1.7595035387785174e-05,1.725128458929248e-05,1.6899512047530152e-05,1.6539826901862398e-05,1.6172331015695818e-05,1.579713716637343e-05,1.541435813123826e-05,1.5024105778138619e-05,1.4626504707848653e-05,1.42216767926584e-05,1.3809746633342002e-05,1.3390847016125917e-05,1.2965108908247203e-05,1.253266691492172e-05,1.2093662007828243e-05,1.164823606814025e-05,1.1196531886525918e-05,1.0738700439105742e-05,1.0274891792505514e-05,9.805258741835132e-06,9.329958629678003e-06,8.849152436596341e-06,8.363000233657658e-06,7.871668458392378e-06,7.375323548330925e-06,6.8741373979719356e-06,6.368282356561394e-06,5.857933501829393e-06,5.3432690947374795e-06,4.824468760489253e-06,4.30171485277242e-06,3.7751931358798174e-06,3.2450898288516328e-06,2.7115943339595105e-06,2.1748983272118494e-06,1.6351943941117497e-06,1.0926784170806059e-06,5.475473017213517e-07,-5.475538866900959e-20,-5.497626034411951e-07,-1.1015382597179268e-06,-1.6551225598959718e-06,-2.2103101855464047e-06,-2.7668936581903836e-06,-3.3246647035412025e-06,-3.883413228322752e-06,-4.442928457137896e-06,-5.00299802297377e-06,-5.563407739828108e-06,-6.123943421698641e-06,-6.684390427835751e-06,-7.244531843753066e-06,-7.804150300216861e-06,-8.363027518498711e-06,-8.920946129364893e-06,-9.477685125602875e-06,-1.0033028047473636e-05,-1.058675206877524e-05,-1.1138638001284562e-05,-1.168846483778907e-05,-1.2236012480570935e-05,-1.2781059012922924e-05,-1.3323384337127209e-05,-1.3862769264960662e-05,-1.4398989151231945e-05,-1.4931828445696738e-05,-1.5461064322153106e-05,-1.598648123035673e-05,-1.650785270612687e-05,-1.7024965927703306e-05,-1.7537602616357617e-05,-1.804554631235078e-05,-1.854857873695437e-05,-1.9046488887397572e-05,-1.9539056665962562e-05,-2.0026074707857333e-05,-2.0507328372332267e-05,-2.098261029459536e-05,-2.1451705833896995e-05,-2.1914411263423972e-05,-2.2370522856363095e-05,-2.281983324792236e-05,-2.326213871128857e-05,-2.369724097661674e-05,-2.4124939955072477e-05,-2.45450391958002e-05,-2.495734406693373e-05,-2.5361661755596288e-05,-2.5757801267900504e-05,-2.614557342894841e-05,-2.652479633979965e-05,-2.689528264454566e-05,-2.725685408222489e-05,-2.7609330572886392e-05,-2.7952541131526232e-05,-2.8286309316172265e-05,-2.861046596080996e-05,-2.8924843718414195e-05,-2.922928069892805e-05,-2.952361865027342e-05,-2.9807695682393387e-05,-3.008136263815686e-05,-3.0344463084475137e-05,-3.059684968320653e-05,-3.0838389648124576e-05,-3.106892836512998e-05,-3.128834214294329e-05,-3.149649273836985e-05,-3.1693245546193793e-05,-3.187848051311448e-05,-3.205207394785248e-05,-3.2213916711043566e-05,-3.236388511140831e-05,-3.25018736475613e-05,-3.2627780456095934e-05,-3.2741500035626814e-05,-3.284294143668376e-05,-3.293200643383898e-05,-3.3008604077622294e-05,-3.307266524643637e-05,-3.312409535283223e-05,-3.3162828913191333e-05,-3.318879316793755e-05,-3.320192627143115e-05,-3.3202166378032416e-05,-3.318945164210163e-05,-3.31637347699143e-05,-3.312497210572474e-05,-3.3073123631766066e-05,-3.300814933027141e-05,-3.29300164594315e-05,-3.28387031913735e-05,-3.273418406024575e-05,-3.261644087615423e-05,-3.248547000112012e-05,-3.2341260521207005e-05,-3.218380516045727e-05,-3.201311847078614e-05,-3.182919681421481e-05,-3.163206929457374e-05,-3.142174318782054e-05,-3.119825487374328e-05,-3.0961622542236e-05,-3.071188257308677e-05,-3.044908407900948e-05,-3.0173261620802805e-05,-2.9884475225117058e-05,-2.9582775823655538e-05,-2.926822708104737e-05,-2.894089266192168e-05,-2.860084714484401e-05,-2.8248165108379908e-05,-2.7882933864020742e-05,-2.7505235266289674e-05,-2.7115163902635686e-05,-2.6712819817475975e-05,-2.6298303055227734e-05,-2.5871728212223388e-05,-2.543319897085894e-05,-2.4982844479382038e-05,-2.4520782972103916e-05,-2.4047143597272225e-05,-2.3562060960102826e-05,-2.306567330379039e-05,-2.2558127966476604e-05,-2.2039575924281962e-05,-2.1510162696358748e-05,-2.0970053810742684e-05,-2.0419414795469493e-05,-1.9858405721606687e-05,-1.928720848809462e-05,-1.8705997717916034e-05,-1.8114957129000686e-05,-1.751427407725714e-05,-1.6904139556572773e-05,-1.628475365578197e-05,-1.565631464472972e-05,-1.5019028978713322e-05,-1.4373107660503592e-05,-1.371876169287134e-05,-1.3056213902018499e-05,-1.2385683476168197e-05,-1.1707397788995877e-05,-1.1021589671145193e-05,-1.03284919532598e-05,-9.628344741940964e-06,-8.921388143789954e-06,-8.207870450860355e-06,-7.4880408647004515e-06,-6.762153589079389e-06,-6.030463737261016e-06,-5.293232788972091e-06,-4.5507244976761285e-06,-3.803205345320748e-06,-3.0509449970850255e-06,-2.294216983500519e-06,-1.533296995148703e-06,-7.684642469030223e-07,2.1141150596524758e-19,7.718113010923844e-07,1.546682938169397e-06,2.3243253508553607e-06,3.1044467050378444e-06,3.886753802362364e-06,4.670950147556141e-06,5.456737198983319e-06,6.243814823392313e-06,7.031881978036836e-06,7.820633982191794e-06,8.609766155132093e-06,9.398971997143235e-06,1.0187942280026618e-05,1.0976369594573043e-05,1.1763939255615696e-05,1.2550345672934782e-05,1.3335270523384679e-05,1.4118403669272084e-05,1.4899432244419586e-05,1.5678038835176267e-05,1.645390693738591e-05,1.722672641335521e-05,1.7996175301959738e-05,1.8761944375000894e-05,1.9523713490343653e-05,2.02811679628212e-05,2.1033994926256128e-05,2.1781876057502814e-05,2.2524502128362656e-05,2.3261556634679437e-05,2.3992724891286343e-05,2.4717697669984773e-05,2.5436162104597315e-05,2.614781078591477e-05,2.6852336304727942e-05,2.7549431251827627e-05,2.8238786399015225e-05,2.892010161303915e-05,2.959307676064782e-05,3.0257408070610836e-05,3.091279722866602e-05,3.155894955853e-05,3.2195581297855824e-05,3.2822383218444884e-05,3.343908247188665e-05,3.404538438189775e-05,3.4641016100067645e-05,3.522569022607058e-05,3.5799126635538414e-05,3.636105975601822e-05,3.6911213101120666e-05,3.744932109839283e-05,3.7975129089318216e-05,3.8488360587507486e-05,3.898877548635937e-05,3.947611548937857e-05,3.995012957602739e-05,4.041057400172576e-05,4.085721593583003e-05,4.128981527173892e-05,4.170814645476639e-05,4.21119766542688e-05,4.250108395353891e-05,4.2875257349805906e-05,4.323428220232017e-05,4.357795478426851e-05,4.3906064092880115e-05,4.4218428229214624e-05,4.4514839828480035e-05,4.479512426769361e-05,4.505909964791499e-05,4.530659134616144e-05,4.553742837742902e-05,4.575145067065023e-05,4.594849451677874e-05,4.612842167261988e-05,4.629107206710614e-05,4.643631473300047e-05,4.6564015065087005e-05,4.66740493720863e-05,4.6766297600697726e-05,4.684064333559945e-05,4.689697379944846e-05,4.693520531873219e-05,4.695522875408642e-05,4.6956960431998596e-05,4.6940323954913765e-05,4.690524656325579e-05,4.685165549744852e-05,4.6779496187809855e-05,4.6688717702636495e-05,4.6579265472246334e-05,4.645111403078772e-05,4.630422336049378e-05,4.613857527147047e-05,4.595414793584496e-05,4.5750941353617236e-05,4.552893733489327e-05,4.5288157707545906e-05,4.5028609747532755e-05,4.475031164474785e-05,4.445328886504285e-05,4.413758506416343e-05,4.3803240259876475e-05,4.3450298107927665e-05,4.307882772991434e-05,4.268888005753979e-05,4.2280542402295396e-05,4.1853887523757294e-05,4.140900637139566e-05,4.094598989468068e-05,4.0464947232976556e-05,3.9965987525647506e-05,3.944922718801536e-05,3.8914793549338356e-05,3.836281757685356e-05,3.779344478971325e-05,3.72068170690909e-05,3.660309448605403e-05,3.598244074964896e-05,3.5345019568922e-05,3.469102011877112e-05,3.402061338420026e-05,3.333400673000142e-05,3.263138569309376e-05,3.19129612762481e-05,3.117895539617166e-05,3.042957905563526e-05,2.966506508528255e-05,2.888564813474659e-05,2.809156649163924e-05,2.7283069357508793e-05,2.646041684783995e-05,2.5623865440138616e-05,2.4773687982815318e-05,2.3910153686301783e-05,2.303354995092377e-05,2.2144160539028235e-05,2.1242281945887953e-05,2.0328210666775703e-05,1.9402259567868896e-05,1.8464737877366133e-05,1.7515962099423632e-05,1.6556261471123435e-05,1.5585956134600565e-05,1.4605391697841696e-05,1.3614903764391784e-05,1.2614839761226904e-05,1.1605551662796643e-05,1.0587395081529394e-05,9.560732905811165e-06,8.525930752512068e-06,7.483361059712479e-06,6.433398084482178e-06,5.376424269343261e-06,4.312823421059875e-06,3.2429854854854057e-06,2.1673031369573437e-06,1.0861742794077145e-06,-9.505224184196046e-20,-1.0908149761235109e-06,-2.1858620584680466e-06,-3.2847294733073795e-06,-4.387002263683826e-06,-5.492261607287219e-06,-6.600087090191664e-06,-7.710053978371434e-06,-8.821734809316695e-06,-9.934702575264964e-06,-1.1048523447243497e-05,-1.2162764505774248e-05,-1.3276991921884473e-05,-1.4390765500138514e-05,-1.5503646864090115e-05,-1.6615194908808917e-05,-1.7724965800880454e-05,-1.8832521163858473e-05,-1.9937411707360297e-05,-2.103919723595027e-05,-2.2137424821266904e-05,-2.3231654267874546e-05,-2.4321434466401115e-05,-2.540632340242155e-05,-2.648586996656377e-05,-2.7559628506423905e-05,-2.8627155188587494e-05,-2.968800072267186e-05,-3.0741721275262535e-05,-3.178787665092386e-05,-3.282601755927317e-05,-3.38557074428536e-05,-3.48765061062295e-05,-3.58879697159864e-05,-3.688966535264626e-05,-3.788115645875223e-05,-3.886201011482626e-05,-3.983180795330554e-05,-4.07901025027968e-05,-4.173647903371602e-05,-4.2670522816479206e-05,-4.35917972936295e-05,-4.4499902287498116e-05,-4.539441943052225e-05,-4.627493763109669e-05,-4.714106034953147e-05,-4.799237285624258e-05,-4.882849316345528e-05,-4.9649024731479585e-05,-5.045357102062553e-05,-5.1241760957054794e-05,-5.201320891501382e-05,-5.276754018268548e-05,-5.3504390962189063e-05,-5.4223393817665055e-05,-5.492419586516917e-05,-5.560644422075711e-05,-5.6269793276442215e-05,-5.691390106221661e-05,-5.753844015998766e-05,-5.814307587570511e-05,-5.872748079127632e-05,-5.9291356592439115e-05,-5.983439041301608e-05,-6.035627666278742e-05,-6.085672430344857e-05,-6.133544957265258e-05,-6.179216870805249e-05,-6.222661613719538e-05,-6.263852264964953e-05,-6.302764086285606e-05,-6.339370884234086e-05,-6.373649375746027e-05,-6.405577732948586e-05,-6.435131217585877e-05,-6.462289456976578e-05,-6.48703207843937e-05,-6.509337981697172e-05,-6.529190432047471e-05,-6.54656978440471e-05,-6.561458576470613e-05,-6.573842256329954e-05,-6.583704816875979e-05,-6.591031706193462e-05,-6.595808372367173e-05,-6.598024629056454e-05,-6.597666651941836e-05,-6.594725709874183e-05,-6.589192344108596e-05,-6.581056368304417e-05,-6.570310506504029e-05,-6.556949665537104e-05,-6.540967297041789e-05,-6.522358307847753e-05,-6.50111905997619e-05,-6.477248098235577e-05,-6.450743967434391e-05,-6.421604484785348e-05,-6.389831833075732e-05,-6.355427467497066e-05,-6.31839211564511e-05,-6.27873232588172e-05,-6.236451008589938e-05,-6.191553984535858e-05,-6.144048529677093e-05,-6.09394337516278e-05,-6.0412465245462954e-05,-5.985967436572537e-05,-5.928118116571568e-05,-5.867710569873452e-05,-5.804757893201895e-05,-5.7392739108763635e-05,-5.671274266205728e-05,-5.600776057690382e-05,-5.5277952924370766e-05,-5.452351979329251e-05,-5.37446430826094e-05,-5.2941533795092255e-05,-5.211440657149069e-05,-5.126349424244836e-05,-5.038902600063011e-05,-4.949124559061602e-05,-4.8570422222837806e-05,-4.7626817831769586e-05,-4.666070526582189e-05,-4.5672371925320476e-05,-4.4662119762506336e-05,-4.363025800557807e-05,-4.257709224475548e-05,-4.150296808802523e-05,-4.040820203954354e-05,-3.9293154259212315e-05,-3.815817035501823e-05,-3.7003617762820795e-05,-3.582987483241595e-05,-3.463731627562083e-05,-3.342633863212541e-05,-3.2197345717577264e-05,-3.095073770964518e-05,-2.9686942070838995e-05,-2.8406380806700327e-05,-2.710948683670722e-05,-2.5796707632252946e-05,-2.446849066473078e-05,-2.3125294319470413e-05,-2.1767591533716768e-05,-2.0395847968757153e-05,-1.901055293274112e-05,-1.7612190276850015e-05,-1.6201258404180408e-05,-1.4778262084291782e-05,-1.334370972472243e-05,-1.1898117918462958e-05,-1.0442008715472184e-05,-8.975913260655943e-06,-7.500365882151527e-06,-6.015909093548544e-06,-4.523088591668056e-06,-3.0224575766624184e-06,-1.5145736824706546e-06,-1.5155480398574397e-19,1.5206957186819636e-06,3.0469407192867948e-06,4.578158950607758e-06,6.1137679949752055e-06,7.653182365174871e-06,9.195813618134707e-06,1.0741067853814457e-05,1.2288348443689756e-05,1.3837059668730944e-05,1.5386593076982535e-05,1.693634840194136e-05,1.8485716282157227e-05,2.003408553719055e-05,2.1580846805591136e-05,2.3125381630961783e-05,2.46670788328629e-05,2.6205319954897277e-05,2.773948472167831e-05,2.9268960133777e-05,3.0793122277827933e-05,3.2311352697433904e-05,3.38230311172083e-05,3.532754271873273e-05,3.6824250855715945e-05,3.8312558899633586e-05,3.979183384217322e-05,4.1261471778852865e-05,4.27208433393389e-05,4.4169340981170535e-05,4.5606349885929376e-05,4.703125887317583e-05,4.844347495236434e-05,4.9842376029118896e-05,5.1227361836936325e-05,5.2597835747292265e-05,5.395320840761997e-05,5.529287955141626e-05,5.66162598261144e-05,5.792277443106286e-05,5.921183037571609e-05,6.0482863773358986e-05,6.173529254738241e-05,6.29685673629865e-05,6.418210978154093e-05,6.537537410622463e-05,6.654781464021653e-05,6.769889296265319e-05,6.882805610075593e-05,6.993478018557653e-05,7.101854862412438e-05,7.207883754745126e-05,7.311514491448179e-05,7.412696140818298e-05,7.511380681535229e-05,7.607517909491435e-05,7.701059803366661e-05,7.791961979819462e-05,7.880175689933822e-05,7.965656550368294e-05,8.048360177781433e-05,8.128244371619076e-05,8.205264748539776e-05,8.279381290776655e-05,8.350552525371313e-05,8.418739162152633e-05,8.483903366141021e-05,8.546006574761122e-05,8.605013135820627e-05,8.660888852318749e-05,8.713595889275894e-05,8.763105870457366e-05,8.809382416075096e-05,8.852397877490148e-05,8.892120968084782e-05,8.928524039220065e-05,8.961579442257062e-05,8.991260983748361e-05,9.017543925438076e-05,9.040405711857602e-05,9.05982160475105e-05,9.075771959032863e-05,9.088238584809005e-05,9.097200381802395e-05,9.10264061531052e-05,9.10454400582239e-05,9.102896729018539e-05,9.097684232983738e-05,9.088895603781566e-05,9.076521382667124e-05,9.060548472916707e-05,9.04097396414727e-05,9.017789125209674e-05,8.990989590529352e-05,8.960570994531736e-05,8.92653115442954e-05,8.888871525414288e-05,8.847590652294457e-05,8.802690717857331e-05,8.75417681527324e-05,8.70205185492523e-05,8.646325295558199e-05,8.587002957938239e-05,8.524095028406009e-05,8.45761169330217e-05,8.387564594158903e-05,8.31396973808296e-05,8.236840221798047e-05,8.156193507602438e-05,8.072047057794407e-05,7.984421245055273e-05,7.893336442066357e-05,7.798815931892022e-05,7.700882270000875e-05,7.599560922244564e-05,7.494880264857784e-05,7.386866491287947e-05,7.27554943296127e-05,7.160961831687018e-05,7.043133518891409e-05,6.92209941917099e-05,6.797895184718072e-05,6.670557195320725e-05,6.540122558362782e-05,6.406632019206882e-05,6.270125595619902e-05,6.130644032964483e-05,5.988232805975713e-05,5.8429348428035155e-05,5.6947967095766217e-05,5.5438657000195235e-05,5.390190563048236e-05,5.233820775174536e-05,5.074807631899603e-05,4.913203156320378e-05,4.7490608267253265e-05,4.582436304190196e-05,4.413383430801332e-05,4.2419607780175284e-05,4.06822728109546e-05,3.8922400563023984e-05,3.714061313075945e-05,3.533752169460058e-05,3.351374471094459e-05,3.166993337799795e-05,2.980672252306249e-05,2.7924774258281104e-05,2.602475433377549e-05,2.4107339413603768e-05,2.217321889474988e-05,2.0223083993187174e-05,1.8257638657814823e-05,1.627759775146842e-05,1.4283679774962366e-05,1.227661869052099e-05,1.0257147550873924e-05,8.226014870160725e-06,6.183969617268303e-06,4.131773948756745e-06,2.070192749670241e-06,-1.5524623964092964e-19,-2.078025090668234e-06,-4.1630978557805065e-06,-6.2544268075725995e-06,-8.351215001312084e-06,-1.0452660717419349e-05,-1.2557958143588621e-05,-1.4666296920040622e-05,-1.6776861230027862e-05,-1.888882979983464e-05,-2.1001384084229358e-05,-2.3113694624044e-05,-2.522493014112115e-05,-2.733426481427159e-05,-2.9440860089380294e-05,-3.154388105031103e-05,-3.364248914294876e-05,-3.573585127014667e-05,-3.782311614486389e-05,-3.9903443393995985e-05,-4.197600355837494e-05,-4.40399453509599e-05,-4.6094428398646414e-05,-4.8138612328330055e-05,-5.017166040488519e-05,-5.219272497924976e-05,-5.4200976592255756e-05,-5.619558214675635e-05,-5.8175704907625914e-05,-6.014051177771762e-05,-6.208918784977868e-05,-6.402088183676824e-05,-6.593480793526396e-05,-6.78301221341826e-05,-6.970603135414422e-05,-7.15617134119384e-05,-7.339638250414282e-05,-7.520921644754708e-05,-7.699944399064407e-05,-7.876627205405384e-05,-8.05089293862693e-05,-8.22266229079105e-05,-8.391860319534317e-05,-8.558411354897544e-05,-8.722239726921543e-05,-8.883271220838651e-05,-9.041433077072725e-05,-9.196650353260338e-05,-9.348853200208396e-05,-9.497971768723801e-05,-9.643934026826173e-05,-9.786672308109701e-05,-9.92611821857281e-05,-0.00010062205547001213,-0.00010194867354584858,-0.00010324041068088263,-0.00010449659748701379,-0.00010571665916359052,-0.00010689994815038517,-0.00010804587509483099,-0.00010915385792031884,-0.00011022329999832436,-0.00011125367018394172,-0.00011224442278034985,-0.00011319499026285484,-0.00011410489241825417,-0.00011497358354972675,-0.0001158005979959853,-0.00011658545554382727,-0.00011732769053196535,-0.00011802685185102746,-0.0001186825247714296,-0.00011929427273571491,-0.00011986169556621462,-0.00012038441491313279,-0.00012086205970263109,-0.00012129429524065927,-0.00012168076500529423,-0.00012202116340631619,-0.00012231517757754773,-0.00012256251648068428,-0.00012276294000912458,-0.00012291617167647928,-0.00012302199320401996,-0.0001230801863130182,-0.0001230905472766608,-0.00012305291602388024,-0.0001229671179316938,-0.0001228330220328644,-0.00012265048280823976,-0.00012241941294632852,-0.00012213973968755454,-0.0001218113538925536,-0.0001214342555613257,-0.00012100837921025231,-0.00012053373939124867,-0.00012001032882835716,-0.00011943817662540823,-0.00011881733371410519,-0.00011814787285402417,-0.00011742987408069894,-0.00011666343925753608,-0.00011584870662773028,-0.00011498579260660335,-0.00011407489364501089,-0.0001131161698140204,-0.00011210982484044507,-0.00011105609883088619,-0.00010995522461598739,-0.00010880745685426518,-0.00010761307930806652,-0.00010637238301569596,-0.00010508570267120376,-0.00010375337296864018,-0.00010237573587801307,-0.00010095318430103362,-9.948611113941297e-05,-9.797492384677753e-05,-9.642005898058414e-05,-9.48219676502049e-05,-9.318112279288471e-05,-9.14979973458685e-05,-8.977312973001972e-05,-8.800702198641375e-05,-8.620021981187165e-05,-8.435329800704494e-05,-8.246681682066992e-05,-8.054138015722856e-05,-7.857760647311807e-05,-7.657612150069326e-05,-7.453758735209703e-05,-7.246265158755705e-05,-7.035200542304665e-05,-6.820633279858157e-05,-6.602638313779607e-05,-6.381285493262112e-05,-6.156650488264859e-05,-5.928809696342796e-05,-5.697840970242396e-05,-5.4638228903058916e-05,-5.226836583460681e-05,-4.986964268027805e-05,-4.7442899813177064e-05,-4.498898488236591e-05,-4.250875281286426e-05,-4.000308399554342e-05,-3.7472880649147555e-05,-3.491903771646321e-05,-3.234246833017096e-05,-2.9744098355877213e-05,-2.712487730605062e-05,-2.448574741720222e-05,-2.182767457270529e-05,-1.915163011290133e-05,-1.6458599930047058e-05,-1.3749575373367406e-05,-1.1025560525013134e-05,-8.287570381071419e-06,-5.536624485102948e-06,-2.7737548862205585e-06,6.9345078821067425e-19,2.7835928904096363e-06,5.575969225901645e-06,8.37606694403803e-06,1.1182818525412586e-05,1.3995148037793115e-05,1.6811976820463315e-05,1.9632216208265163e-05,2.245477298856713e-05,2.5278555767727084e-05,2.8102460419177078e-05,3.092538099735975e-05,3.374621883267537e-05,3.656384797068313e-05,3.9377166103804484e-05,4.218505637254566e-05,4.4986391003476456e-05,4.778006405103952e-05,5.056494410382584e-05,5.3339921578299254e-05,5.610386506305076e-05,5.88556649745442e-05,6.159419717732817e-05,6.431833025999367e-05,6.702697282889858e-05,6.97190043865703e-05,7.239329715957865e-05,7.50487670302391e-05,7.768427894916385e-05,8.0298756074626e-05,8.289110701298341e-05,8.546021854272112e-05,8.800501382211223e-05,9.052440873347223e-05,9.301733371103182e-05,9.548272646497935e-05,9.791951742954552e-05,0.00010032664431491867,0.0001027030884870328,0.00010504779493203387,0.00010735973773989826,0.00010963790555251762,0.00011188127973582596,0.00011408887075958773,0.00011625968181760982,0.00011839274520752952,0.00012048707867506891,0.0001225417508976534,0.00012455580872483552,0.00012652832083404064,0.0001284583704546094,0.0001303450553677976,0.0001321875024586916,0.00013398483861237764,0.0001357361616101116,0.00013744068564847112,0.00013909752306062728,0.0001407059171469882,0.00014226502389647067,0.000143774101161398,0.00014523236313834786,0.00014663906767964363,0.00014799348718952388,0.00014929492317605764,0.0001505426480434835,0.0001517360215075314,0.00015287440328393131,0.0001539571094326675,0.00015498354332521558,0.0001559531519887969,0.00015686529513914138,0.00015771944890730083,0.00015851508942432702,0.00015925169282127172,0.00015992874978110194,0.00016054582374636084,0.0001611024490557611,0.0001615982037037611,0.00016203266568481922,0.0001624055003048852,0.00016271630011033267,0.00016296477406285703,0.0001631505583645776,0.00016327339108102024,0.0001633330393815413,0.00016332922677975148,0.00016326174954883754,0.0001631304039619863,0.00016293504450004548,0.00016267549654003233,0.00016235167277045548,0.00016196347132790834,0.00016151081945281476,0.0001609936443855986,0.00016041198978200555,0.00015976581198628992,0.00015905516920611262,0.00015828009054530412,0.00015744069241918623,0.00015653707669116557,0.00015556934522464871,0.00015453770174644887,0.00015344230632763356,0.00015228336269501597,0.0001510611327830702,0.00014977584942243993,0.0001484278473071754,0.00014701737381983548,0.00014554482186213136,0.00014401052612811327,0.00014241489407140762,0.00014075830404181033,0.0001390412508044392,0.00013726417091675103,0.00013542755914386362,0.00013353191025089473,0.00013157779176253825,0.0001295657712034881,0.0001274964160984382,0.00012537035217974335,0.0001231882197316736,0.00012095068086637184,0.00011865841952385381,0.0001163121487479657,0.00011391259613446891,0.00011146052565891296,0.00010895671584876254,0.00010640195978339761,0.00010379710147390142,0.00010114297765539959,9.844046871876344e-05,9.569044777890667e-05,9.28938461584039e-05,9.005159517982975e-05,8.716465526958928e-05,8.423399413004518e-05,8.126060856739059e-05,7.824552449164912e-05,7.518977508880198e-05,7.209441537270322e-05,6.896052946103737e-05,6.578919419553131e-05,6.258155190153047e-05,5.93386976106558e-05,5.6061806390061975e-05,5.275203147903085e-05,4.941055885865353e-05,4.6038585423957556e-05,4.2637326259864494e-05,3.920801464118995e-05,3.5751891118707135e-05,3.227021807106212e-05,2.8764272428816184e-05,2.523533839848824e-05,2.1684716557501815e-05,1.8113723854185082e-05,1.4523683603329118e-05,1.0915935490629636e-05,7.291831025213469e-06,3.652728764791391e-06,-2.2821969969005147e-19,-3.664973974082386e-06,-7.340802312683081e-06,-1.102608712244546e-05,-1.4719420505571179e-05,-1.8419385014567524e-05,-2.2124560928205028e-05,-2.5833518520812504e-05,-2.9544817152782343e-05,-3.325702346046455e-05,-3.69686858903151e-05,-4.0678351069800556e-05,-4.438456744537689e-05,-4.8085876187542453e-05,-5.17808148288168e-05,-5.546792090171948e-05,-5.9145728300791234e-05,-6.2812767282594e-05,-6.64675681036897e-05,-7.010867557255551e-05,-7.373461266979575e-05,-7.734390237601474e-05,-8.093510405160487e-05,-8.450674795312807e-05,-8.805735706118867e-05,-9.158549073617905e-05,-9.508970833849162e-05,-9.856853284873068e-05,-0.00010202054545516148,-0.0001054443055181764,-0.00010883836512221023,-0.00011220133455935866,-0.00011553176591405645,-0.00011882826220244169,-0.00012208943371661007,-0.00012531387619674206,-0.00012850022176280618,-0.00013164710253477097,-0.00013475313608068973,-0.00013781699817627668,-0.00014083732094150037,-0.0001438128383597359,-0.00014674219710286707,-0.00014962411660235375,-0.00015245730173774064,-0.00015524050104431808,-0.00015797244850546122,-0.00016065192176029086,-0.00016327771299984306,-0.0001658485853113234,-0.00016836338909342885,-0.0001708209456410259,-0.0001732200908008963,-0.00017555973317939788,-0.00017783872317522764,-0.00018005598394665867,-0.0001822104532038793,-0.00018430108320899308,-0.00018632685532793403,-0.0001882867654785514,-0.0001901798095786944,-0.00019200504175387323,-0.00019376153068151325,-0.0001954483741428703,-0.00019706466991920024,-0.0001986095739994198,-0.00020008219871670008,-0.00020148178737144917,-0.00020280755416024476,-0.0002040586987277493,-0.00020523453713394701,-0.0002063343272311613,-0.00020735739963129163,-0.00020830311405006796,-0.00020917083020322025,-0.00020995996601413935,-0.00021066995395813137,-0.00021130024106241763,-0.0002118503616657108,-0.00021231982100289315,-0.00021270816796459258,-0.00021301496599335223,-0.00021323985129129142,-0.00021338248916435987,-0.00021344251581467688,-0.0002134196402039379,-0.000213313614949584,-0.00021312423632480204,-0.0002128512569470331,-0.00021249454584904015,-0.00021205392840784043,-0.0002115293755196035,-0.00021092074166517705,-0.0002102280268445611,-0.00020945124560967088,-0.00020859039796050638,-0.0002076455275528133,-0.0002066167799057439,-0.00020550427143462002,-0.00020430810400284827,-0.0002030285686487332,-0.0002016658108914271,-0.000200220150873065,-0.00019869182142429054,-0.0001970812154468149,-0.00019538866763468832,-0.00019361454178579152,-0.00019175931811332703,-0.00018982341862283647,-0.0001878073380794376,-0.0001857116149039939,-0.0001835368457250297,-0.00018128355441149324,-0.00017895238124765456,-0.00017654402472544461,-0.00017405912512913346,-0.00017149843915831298,-0.0001688627089606598,-0.00016615269123576581,-0.00016336922999471426,-0.00016051319835241884,-0.00015758542576804757,-0.00015458684356417507,-0.00015151839761529118,-0.00014838103379588574,-0.0001451757998438552,-0.0001419036852894351,-0.0001385657669743523,-0.00013516312174033374,-0.00013169687008485198,-0.00012816819071304053,-0.00012457820412237197,-0.00012092815450159833,-0.00011721925693564117,-0.0001134527483372949,-0.00010962993837893009,-0.00010575212945695966,-0.00010182066762354225,-9.783689165487885e-05,-9.380218398291618e-05,-8.971797797130421e-05,-8.558567787986249e-05,-8.140677527990192e-05,-7.718271081103012e-05,-7.291501970030367e-05,-6.860518624307588e-05,-6.425479659810662e-05,-5.9865396906388924e-05,-5.543856605072506e-05,-5.097592293168418e-05,-4.647908644983545e-05,-4.194970097159967e-05,-3.7389421777334064e-05,-3.279993688920513e-05,-2.8182937967358157e-05,-2.3540131223853678e-05,-1.887325015559327e-05,-1.4184031897457317e-05,-9.474236321693752e-06,-4.745631031255471e-06,2.668340674970695e-19,4.760862339026062e-06,9.535148819850292e-06,1.43210427268059e-05,1.9116712792310864e-05,2.392032547504641e-05,2.8730035410262644e-05,3.3543976314831525e-05,3.8360296457540244e-05,4.3177125917281955e-05,4.79925874969922e-05,5.280480036162771e-05,5.761186912423e-05,6.24119202257134e-05,6.720305100316182e-05,7.198336970759556e-05,7.67509700381197e-05,8.150396752171218e-05,8.624045585747808e-05,9.095852874452248e-05,9.565630898578092e-05,0.0001003318902803585,0.00010498336632736027,0.00010960887448163703,0.00011420651571825147,0.00011877439828822389,0.00012331065954640508,0.0001278134441236034,0.0001322808675467968,0.00013671108172275126,0.000141102253110148,0.00014545254816766828,0.0001497601333539933,0.0001540231896797195,0.00015823989815544337,0.00016240851255133748,0.00016652722842991352,0.00017059428500942886,0.00017460795061197132,0.0001785664790077135,0.000182468123966828,0.000186311241122894,0.00019009409879799932,0.00019381505262572318,0.00019747245823964477,0.00020106470037717372,0.00020459013467188925,0.00020804721862077713,0.0002114343806169927,0.00021475004905369133,0.00021799272508360445,0.00022116090985946357,0.00022425313363783062,0.0002272679703310132,0.0002302039647474885,0.00023305974900722504,0.00023583396978210658,0.00023852525919210166,0.00024113230756483972,0.0002436538488836959,0.00024608863168396056,0.0002484354190528393,0.0002506930031813681,0.0002528602781239897,0.0002549360506236553,0.00025691924383863807,0.0002588088682387024,0.00026060373056679964,0.00026230295770801604,0.00026390558923594654,0.0002654106356203556,0.0002668171946424991,0.0002681245096027851,0.0002693316200748086,0.0002704378275666386,0.00027144240448251367,0.00027234453591518104,0.0002731436106842011,0.0002738390467129648,0.0002744301746133715,0.0002749163832049817,0.0002752972941379994,0.00027557232533581555,0.00027574104024097323,0.000275803089607507,0.0002757580659817904,0.00027560567832551897,0.0002753456064965576,0.0002749776467680931,0.00027450162451714277,0.0002739173360168934,0.0002732246939558536,0.000272423611022532,0.0002715140872169286,0.0002704961225390434,0.0002693697460927069,0.0002681350742932409,0.00026679225265979767,0.00026534145581535995,0.0002637829165905714,0.00026211689691990614,0.00026034374604932964,0.000258463725913316,0.0002564772730693221,0.0002543848822824657,0.0002521869901102036,0.00024988409131765366,0.0002474767970852554,0.0002449657185934484,0.00024235149612650275,0.00023963481362443417,0.00023681639868300408,0.00023389705165755004,0.0002308775729034096,0.0002277588500874117,0.00022454175632447004,0.0002212272520409897,0.0002178163267672062,0.00021430998458527029,0.00021070930233690888,0.00020701538596767932,0.00020322937052696943,0.0001993524783756584,0.00019538590277079493,0.00019133088062517345,0.00018718877981882542,0.00018296086636837572,0.00017864856636151671,0.00017425327678211033,0.00016977646737359464,0.00016521959332749248,0.00016058419714681804,0.00015587183588650078,0.00015108408115338534,0.000146222606417723,0.00014128899783827364,0.00013628504530061036,0.0001312124077230692,0.00012607284588739276,0.00012086817878298461,0.00011560021084733307,0.00011027079744962975,0.00010488183761481196,9.943520853994414e-05,9.393286745762452e-05,8.837679342832416e-05,8.27689582365565e-05,7.71113918744959e-05,7.140613888623193e-05,6.565527291968465e-05,5.986087489873171e-05,5.402508395491168e-05,4.815002830582671e-05,4.223787254886702e-05,3.629081038525328e-05,3.0311031878227368e-05,2.4300772565766238e-05,1.8262266166857444e-05,1.2197783689771313e-05,6.109595688030822e-06,-3.0534379695659953e-19,-6.128694167273352e-06,-1.2274163054826204e-05,-1.8434067897032946e-05,-2.4606057195342146e-05,-3.0787767173023894e-05,-3.6976824048906565e-05,-4.31708394899033e-05,-4.936742698191665e-05,-5.5564185458933935e-05,-6.175869202706963e-05,-6.794854562031105e-05,-7.413130515487865e-05,-8.030456956475973e-05,-8.646588685223833e-05,-9.261283412342891e-05,-9.874296665657312e-05,-0.00010485385428182781,-0.00011094305955339223,-0.00011700814502546564,-0.0001230466878041625,-0.00012905623589176685,-0.00013503436639439315,-0.00014097867824602872,-0.00014688671217299998,-0.00015275611076503992,-0.0001585844438523054,-0.00016436929581686854,-0.00017010830924846232,-0.00017579911218490452,-0.0001814393326640129,-0.00018702659872360528,-0.00019255861116107553,-0.00019803305622190237,-0.00020344756194390357,-0.00020879988733213395,-0.00021408773318398744,-0.00021930885850451887,-0.00022446100774686784,-0.00022954196901991963,-0.00023454957408830523,-0.00023948162561282516,-0.0002443359699100256,-0.0002491104824002832,-0.0002538030385039747,-0.0002584115427453071,-0.00026293404516763985,-0.00026736839208751917,-0.0002717126626521349,-0.0002759648486971855,-0.00028012305847369134,-0.0002841853420250118,-0.00028814980760216713,-0.00029201467987149954,-0.00029577803798019886,-0.0002994382521137595,-0.0003029934305232018,-0.00030644191429018974,-0.00030978210270404816,-0.00031301224953494966,-0.0003161308413837105,-0.00031913627753965557,-0.0003220270446036011,-0.00032480168738402426,-0.0003274586924817413,-0.0003299967502243817,-0.0003324144927319139,-0.00033471055212430656,-0.00033688367693684995,-0.00033893270301632583,-0.0003408563497941941,-0.0003426535113248974,-0.0003443231398705393,-0.0003458641585893929,-0.0003472756070550531,-0.00034855646663345397,-0.0003497058351058513,-0.0003507229557726532,-0.0003516068682074547,-0.00035235699033364654,-0.000352972507243976,-0.00035345274955034256,-0.00035379716427996755,-0.0003540051693562418,-0.0003540762700140476,-0.0003540100296959281,-0.0003538060118444264,-0.00035346386721357703,-0.0003529833338689059,-0.00035236412077210844,-0.00035160614061169326,-0.0003507091023493558,-0.000349673064192757,-0.000348497909726575,-0.0003471837262623012,-0.0003457305137999356,-0.0003441384469624609,-0.0003424077294766903,-0.0003405385941732675,-0.000338531332090497,-0.00033638632157817483,-0.00033410394098609686,-0.0003316845977678895,-0.00032912890310399234,-0.00032643740996718407,-0.00032361067133024335,-0.00032064938568510115,-0.0003175543970428407,-0.00031432631658390164,-0.00031096613383851945,-0.0003074746928177774,-0.0003038529248442501,-0.00030010181944817305,-0.0002962225116789341,-0.00029221599106676877,-0.00028808353818021715,-0.0002838262589648366,-0.0002794455213006586,-0.00027494257665239275,-0.00027031879290007055,-0.0002655756543390453,-0.0002607145579531789,-0.000255737075349316,-0.0002506447781343013,-0.00024543923791497946,-0.00024012218636926264,-0.00023469531151931733,-0.00022916035959497094,-0.00022351917868945748,-0.00021777361689601094,-0.0002119256096193567,-0.00020597706316038966,-0.00019993001478724182,-0.00019378647266421467,-0.00018754854681901634,-0.0001812183763831854,-0.0001747981004882604,-0.0001682899601291865,-0.00016169619630090892,-0.0001550191082060337,-0.0001482610241509974,-0.00014142433064989746,-0.00013451142876874655,-0.00012752476322930306,-0.00012046682240907103,-0.00011334013834130019,-0.0001061472503351979,-9.889074135571718e-05,-9.157324529951438e-05,-8.419739606324583e-05,-7.676590030314401e-05,-6.928145012352616e-05,-6.174680311232805e-05,-5.416471685748547e-05,-4.653798896470107e-05,-3.886945341946557e-05,-3.116194056929089e-05,-2.3418337150360458e-05,-1.56415317178471e-05,-7.834440111764707e-06,3.42602027998731e-19,7.858832759666257e-06,1.5739082300569862e-05,2.363775456615258e-05,3.155184458591975e-05,3.947832010453567e-05,4.741414522868581e-05,5.535627497010864e-05,6.330163887469098e-05,7.124716648831964e-05,7.918976189102978e-05,8.71263473527506e-05,9.505381603958085e-05,0.00010296906839357689,0.00011086898302892223,0.000118750445835758,0.00012661036453209817,0.00013444559590425342,0.00014225300401449203,0.00015002951840870082,0.00015777199587319046,0.00016547735140193254,0.00017314244178123772,0.0001807641820050776,0.0001883394579635933,0.0001958652283065021,0.00020333840802777559,0.0002107558975694701,0.0002181146846851334,0.00022541169892065227,0.00023264392802957445,0.00023980835976544768,0.0002469019964337349,0.00025392192765139043,0.00026086511206813157,0.0002677286684047431,0.0002745096280705184,0.00028120516799390316,0.0002878124068956822,0.0002943284634966403,0.0003007505729328841,0.0003070759412366897,0.00031330177444033325,0.00031942539499141276,0.00032544409623369575,0.0003313552006147802,0.000337156088789925,0.00034284417051821947,0.000348416855558753,0.0003538716700859368,0.00035920608206652105,0.00036441764677874744,0.00036950400681234896,0.0003744628047570586,0.0003792916249949485,0.0003839882556349039,0.0003885504265781492,0.0003929760423488915,0.0003972628037445247,0.0004014087899122387,0.0004054117889609188,0.0004092699382454157,0.000412981171393767,0.00041654365486465394,0.00041995549690909684,0.00042321498040109873,0.0004263203009031713,0.00042926977039314806,0.00043206175905652344,0.0004346947534941137,0.00043716715299524367,0.000439477531472221,0.0004416244919411838,0.00044360666652210057,0.00044542280375026166,0.00044707165216095746,0.0004485520184971392,0.00044986288412474096,0.00045100314309820533,0.0004519718640949577,0.00045276808668859303,0.00045339096686802804,0.0004538397479336709,0.0004541137022897601,0.00045421210234053433,0.0004541344824247062,0.0004538802895694971,0.00045344902900978923,0.0004528402932919562,0.0004520537913776934,0.00045108929043635726,0.0004499465867411345,0.0004486255347728729,0.000447126105427742,0.0004454483569134027,0.00044359234743751585,0.0004415582225192338,0.00043934627319686115,0.00043695670319721103,0.00043438997818157077,0.00043164644739590585,0.00042872666381299496,0.0004256312095094472,0.0004223606956657022,0.00041891587898135185,0.00041529754525981843,0.0004115065385121852,0.00040754376095719635,0.00040341023122891784,0.00039910702616907656,0.0003946352517232299,0.000389996130252257,0.00038519094232469797,0.0003802209976129234,0.0003750877222046256,0.0003697925712913275,0.0003643370873760432,0.0003587229293771088,0.00035295169800519943,0.0003470251976978034,0.00034094517468474805,0.00033471357892267406,0.00032833227305673063,0.0003218033234588802,0.00031512873829342425,0.0003083106130361557,0.0003013512468896806,0.0002942528226412833,0.00028701763949356973,0.0002796481130644679,0.00027214662986807525,0.0002645157219376415,0.0002567578630987555,0.00024887576000764966,0.00024087201745714992,0.00023274935665540397,0.0002245105424663052,0.0002161583979614079,0.0002076958044199273,0.00019912571588065475,0.00019045108638238162,0.0001816749427234754,0.0001728003699099645,0.00016383051115553826,0.00015476852422580123,0.00014561761054210365,0.00013638105883728713,0.0001270621723961085,0.00011766428360715508,0.0001081907976185903,9.864514868240803e-05,8.903079287847504e-05,7.935124449431896e-05,6.96100396453403e-05,5.9810769016621634e-05,4.99570305692032e-05,4.00524731958285e-05,3.01007730740821e-05,2.0105633666389622e-05,1.0070788448501844e-05,-3.7749896858475327e-19,-1.0102946362167131e-05,-2.0234238036209717e-05,-3.039004332094919e-05,-4.056650504935533e-05,-5.075974331703037e-05,-6.096587094361894e-05,-7.11809698259458e-05,-8.140111458487809e-05,-9.162236528936774e-05,-0.00010184076381847262,-0.00011205233749933541,-0.00012225312821101397,-0.00013243910507299006,-0.00014260632451623678,-0.00015275078476406634,-0.00016286845493596047,-0.00017295536235906184,-0.00018300746160093695,-0.0001930207945406437,-0.00020299131574574858,-0.0002129150670953095,-0.0002227880322607234,-0.00023260622401721776,-0.00024236566969193518,-0.0002520624257158488,-0.0002616924757603556,-0.00027125191991217434,-0.0002807368291541934,-0.0002901432744693011,-0.00029946735594421625,-0.000308705260977149,-0.00031785303144715726,-0.00032690694206394255,-0.00033586312201805413,-0.00034471775870770216,-0.0003534671850502491,-0.00036210755934007466,-0.0003706353309098631,-0.00037904668715782464,-0.00038733816472813487,-0.00039550598012283444,-0.000403546669986099,-0.00041145674185827374,-0.00041923264507204294,-0.00042687097447924316,-0.0004343682958278805,-0.0004417212912812829,-0.0004489265847951174,-0.00045598100405186415,-0.0004628812603186816,-0.00046962418127804995,-0.0004762066528201103,-0.0004826256772503257,-0.0004888781113550067,-0.0004949611029587686,-0.0005008716834709048,-0.0005066070589236915,-0.0005121644353494048,-0.0005175410769879818,-0.0005227342480793595,-0.0005277413874864578,-0.0005325599922798574,-0.000537187559530139,-0.0005416216445155442,-0.0005458599771372974,-0.0005499001126736403,-0.0005537400720641017,-0.0005573775270022452,-0.0005608105566352606,-0.000564037065487355,-0.0005670552491210401,-0.000569863012060523,-0.00057245884090662,-0.0005748409312218428,-0.0005770076531916857,-0.000578957493416965,-0.000580688938498497,-0.0005822006496600807,-0.0005834914045408368,-0.0005845598061569035,-0.0005854047485627234,-0.0005860253586433828,-0.0005864204140380025,-0.0005865891580469906,-0.0005865307757630944,-0.0005862445686943829,-0.0005857297801412642,-0.000584985944442451,-0.000584012595936656,-0.0005828093271702528,-0.0005813759053125978,-0.0005797120393253863,-0.0005778177874162793,-0.0005756928585469723,-0.0005733374855481088,-0.0005707518430426717,-0.0005679360474459827,-0.0005648905062116683,-0.0005616156267933547,-0.0005581119912676513,-0.0005543800652958453,-0.0005504206637851894,-0.0005462344852276146,-0.0005418224609456956,-0.0005371854640543461,-0.0005323245422914624,-0.0005272408598102629,-0.0005219356971792877,-0.0005164103349670768,-0.0005106662283651531,-0.0005047047743573785,-0.0004985276609659195,-0.0004921364015899599,-0.0004855329461861402,-0.00047871898277662694,-0.0004716965777333826,-0.0004644676810130477,-0.00045703438809141517,-0.00044939893996343017,-0.0004415636067278683,-0.0004335306875873357,-0.0004253026854712516,-0.00041688213241286576,-0.0004082716186530888,-0.00039947385084815323,-0.0003904915938619524,-0.00038132769986987114,-0.00037198513746261597,-0.0003624668752308935,-0.00035277599818073213,-0.0003429157368373126,-0.0003328892635181546,-0.00032269995426759124,-0.0003123511269222945,-0.0003018463321495801,-0.0002911890624091029,-0.00028038289747200906,-0.000269431562628597,-0.0002583388122729957,-0.0002471083716955036,-0.00023574416991323233,-0.00022425016504712403,-0.00021263034432195127,-0.00020088876772206277,-0.00018902953888755292,-0.0001770569069776684,-0.000164975062943995,-0.00015278832870535553,-0.00014050101162865758,-0.0001281175937037915,-0.00011564247688511387,-0.00010308017954230309,-9.043527825269848e-05,-7.771235686959699e-05,-6.49160792818293e-05,-5.205113484407775e-05,-3.912226020474918e-05,-2.6134230211027898e-05,-1.309185699938098e-05,4.0899536967257005e-19,1.3136455891071819e-05,2.631258757901378e-05,3.9523445593658835e-05,5.276403680909425e-05,6.602936628041789e-05,7.931436994113028e-05,9.261401282856241e-05,0.00010592319449642673,0.00011923679994652048,0.0001325497287325561,0.00014585680037271231,0.00015915289986878633,0.0001724328176351264,0.00018569137318991125,0.00019892341515515,0.00021212370484136045,0.00022528704721480608,0.00023840824724175036,0.0002514820662327111,0.0002645032946020365,0.00027746675186790526,0.00029036725754849613,0.00030319951474666595,0.0003159584302920848,0.0003286388237029314,0.0003412354562897235,0.0003537432348821312,0.00036615700810216367,0.0003784716536756605,0.0003906821075361222,0.0004027832474093884,0.00041477003833279014,0.0004266374744474888,0.00043838057899847627,0.00044999431702308357,0.00046147379907779396,0.0004728141939267516,0.00048401058302260935,0.0004950580769218504,0.0005059519899077713,0.0005166875780560076,0.0005272600683383644,0.0005376649205572903,0.0005478974198922515,0.0005579530843533576,0.0005678274319507182,0.000577515980694443,0.0005870143650099635,0.0005963182775303721,0.0006054233526811004,0.0006143254577182233,0.0006230204598978162,0.0006315042264759541,0.0006397727993316948,0.0006478221039287746,0.0006556484149768949,0.0006632478907704353,0.0006706166896037757,0.0006777513190172613,0.0006846481701359153,0.0006913036340847611,0.0006977143348194659,0.0007038770127110183,0.0007097883499227464,0.0007154451450332999,0.0007208444294519722,0.0007259830599650741,0.0007308581843972206,0.000735467066988349,0.0007398068555630744,0.0007438750471919775,0.0007476689643226564,0.0007511863368563354,0.0007544246618635952,0.0007573817274533212,0.0007600554963573813,0.0007624438730999827,0.0007645449368283153,0.0007663567084819078,0.0007678776164539158,0.0007691059727221727,0.0007700402638874948,0.0007706790347583592,0.0007710210047662258,0.0007710650097578764,0.0007708098855800927,0.0007702547009103,0.0007693985826335847,0.0007682408322580159,0.0007667806930840015,0.0007650177576579154,0.0007629515021108091,0.0007605816936120391,0.0007579081575386226,0.0007549307192675769,0.0007516496116295457,0.0007480647182092071,0.0007441765628755093,0.0007399854948744178,0.0007354919798672199,0.0007306966581381857,0.0007256002281792462,0.0007202036213129759,0.0007145078852772713,0.000708513951394707,0.0007022232166491449,0.0006956368451938033,0.0006887564086355269,0.0006815834203734994,0.0006741196266375482,0.0006663668318651617,0.000658326898701489,0.000650001922622323,0.0006413940573111176,0.0006325055146589875,0.000623338739387691,0.0006138962344266474,0.0006041805609129369,0.0005941945710219443,0.0005839409423060715,0.000573422817979008,0.0005626431084237993,0.0005516050732694566,0.0005403119721449912,0.0005287672393023968,0.0005169743672013283,0.0005049369647167623,0.0004926587571389973,0.0004801435861736536,0.0004673953226301819,0.0004544180992525071,0.0004412159905768931,0.00042779321665875614,0.00041415420128032565,0.0004003032809123397,0.00038624508306384087,0.0003719841770362109,0.0003575253067538142,0.0003428732743486762,0.00032803299836814404,0.00031300951377488673,0.00029780788463540375,0.0002824332914315164,0.000266890914645046,0.00025118625489994884,0.0002353245799895376,0.00021931150695309043,0.0002031525655183941,0.0001868534309323877,0.00017041985120158643,0.00015385760343633592,0.00013717258116230369,0.00012037075066473335,0.00010345811460865662,8.644074114272371e-05,6.932477845111862e-05,5.2116440201643854e-05,3.4821972803911194e-05,1.744770270306617e-05,-4.361531567487579e-19,-1.751470881572459e-05,-3.508994996082038e-05,-5.2719198720296845e-05,-7.03958939993754e-05,-8.811341831460595e-05,-0.00010586513235466555,-0.0001236443204106763,-0.00014144428132567555,-0.00015925827028695494,-0.00017707944789435714,-0.00019490103295538574,-0.0002127161860698834,-0.00023051799507811666,-0.00024829962057992816,-0.000266054121311754,-0.00028377457056194544,-0.0003014540416188538,-0.00031908557866699994,-0.00033666222589090466,-0.00035417702747508883,-0.00037162299850024283,-0.0003889931831508875,-0.0004062805965077132,-0.00042347825365141034,-0.00044057925697416067,-0.00045757662155665457,-0.0004744634497910738,-0.0004912327858619392,-0.0005078777321614325,-0.000524391420185566,-0.0005407669814303517,-0.000556997605599463,-0.0005730764241889119,-0.0005889967433176935,-0.0006047518108971417,-0.0006203348748385906,-0.0006357392994686961,-0.000650958449114114,-0.0006659857463091612,-0.0006808146717958152,-0.0006954387645237148,-0.0007098516216501594,-0.0007240466657094657,-0.0007380178431048989,-0.0007517587509937584,-0.0007652631611563265,-0.0007785249617882073,-0.0007915382739156485,-0.0008042968111112714,-0.0008167948690243065,-0.0008290265686810017,-0.0008409860311076045,-0.0008526676683686674,-0.0008640658343210816,-0.0008751749992370605,-0.0008859898080118,-0.0008965047891251743,-0.000906714762095362,-0.0009166145464405417,-0.0009261990780942142,-0.0009354633511975408,-0.0009444026509299874,-0.0009530121460556984,-0.0009612870635464787,-0.00096922303782776,-0.0009768155869096518,-0.0009840602288022637,-0.000990952947176993,-0.0009974895510822535,-0.0010036661988124251,-0.001009478815831244,-0.0010149237932637334,-0.0010199975222349167,-0.0010246963938698173,-0.0010290172649547458,-0.0010329567594453692,-0.0010365118505433202,-0.001039679511450231,-0.0010424568317830563,-0.0010448413668200374,-0.0010468303225934505,-0.0010484213707968593,-0.001049612183123827,-0.0010504006640985608,-0.0010507848346605897,-0.0010507628321647644,-0.0010503330267965794,-0.0010494935559108853,-0.001048243255354464,-0.0010465809609740973,-0.001044505275785923,-0.0010420155012980103,-0.0010391105897724628,-0.001035790191963315,-0.0010320533765479922,-0.0010279002599418163,-0.0010233302600681782,-0.0010183434933423996,-0.0010129401925951242,-0.0010071205906569958,-0.0010008849203586578,-0.0009942339966073632,-0.000987168401479721,-0.000979689066298306,-0.000971797329839319,-0.0009634941234253347,-0.0009547809604555368,-0.0009456593543291092,-0.0009361310512758791,-0.0009261979139409959,-0.0009158618631772697,-0.0009051252854987979,-0.0008939904510043561,-0.0008824597462080419,-0.0008705360232852399,-0.0008582220179960132,-0.0008455207571387291,-0.0008324353257194161,-0.0008189690415747464,-0.0008051254553720355,-0.0007909081177785993,-0.0007763207540847361,-0.0007613673806190491,-0.0007460520719178021,-0.000730379018932581,-0.000714352645445615,-0.0006979774916544557,-0.0006812581559643149,-0.0006641996442340314,-0.000646806787699461,-0.0006290848832577467,-0.0006110391113907099,-0.0005926748854108155,-0.0005739978514611721,-0.0005550136556848884,-0.0005357281770557165,-0.0005161474691703916,-0.0004962775274179876,-0.0004761247255373746,-0.0004556954081635922,-0.00043499612365849316,-0.0004140335659030825,-0.0003928144578821957,-0.00037134578451514244,-0.00034963450161740184,-0.0003276877978350967,-0.00030551303643733263,-0.0002831175224855542,-0.00026050882297568023,-0.0002376945485593751,-0.0002146824263036251,-0.00019148032879456878,-0.0001680962013779208,-0.00014453809126280248,-0.00012081419117748737,-9.693273023003712e-05,-7.290209032362327e-05,-4.873070793109946e-05,-2.442713775963057e-05,4.581634505718166e-19,2.4541985112591647e-05,4.9190020945388824e-05,7.39352180971764e-05,9.876863623503596e-05,0.00012368122406769544,0.00014866390847600996,0.00017370747809763998,0.00019880273612216115,0.00022394036932382733,0.00024911100626923144,0.0002743052609730512,0.00029951363103464246,0.0003247266577091068,0.0003499347367323935,0.00037512826384045184,0.00040029757656157017,0.0004254330706316978,0.0004505249671638012,0.0004755635163746774,0.0005005389684811234,0.0005254415445961058,0.0005502614076249301,0.000574988778680563,0.0005996137042529881,0.000624126463662833,0.0006485171034000814,0.0006727758445776999,0.0006968927918933332,0.000720858050044626,0.0007446618983522058,0.0007682943250983953,0.0007917457260191441,0.0008150061476044357,0.0008380658691748977,0.0008609152282588184,0.0008835443877615035,0.0009059436852112412,0.000928103516343981,0.000950014335103333,0.0009716664208099246,0.0009930504020303488,0.0010141568491235375,0.001034976332448423,0.001055499422363937,0.0010757169220596552,0.0010956196347251534,0.0011151982471346855,0.0011344439117237926,0.0011533476645126939,0.001171900425106287,0.001190093462355435,0.0012079180451110005,0.001225365442223847,0.0012424273882061243,0.0012590950354933739,0.0012753602350130677,0.001291214837692678,0.0013066506944596767,0.0013216596562415361,0.0013362339232116938,0.0013503654627129436,0.001364047173410654,0.0013772710226476192,0.001390029676258564,0.0014023160329088569,0.0014141228748485446,0.0014254432171583176,0.0014362703077495098,0.0014465972781181335,0.0014564174925908446,0.0014657247811555862,0.001474512740969658,0.0014827754348516464,0.001490506692789495,0.001497700926847756,0.0015043524326756597,0.0015104558551684022,0.0015160058392211795,0.0015209974953904748,0.001525425584986806,0.0015292855678126216,0.0015325729036703706,0.0015352830523625016,0.0015374121721833944,0.0015389558393508196,0.0015399105614051223,0.0015402727294713259,0.0015400387346744537,0.0015392055502161384,0.0015377701492980123,0.0015357296215370297,0.0015330812893807888,0.0015298229409381747,0.0015259524807333946,0.0015214676968753338,0.0015163668431341648,0.0015106482896953821,0.001504311105236411,0.001497353776358068,0.0014897753717377782,0.0014815755421295762,0.0014727534726262093,0.0014633092796429992,0.0014532427303493023,0.0014425539411604404,0.0014312434941530228,0.0014193120878189802,0.0014067604206502438,0.0013935897732153535,0.0013798015424981713,0.0013653971254825592,0.0013503785012289882,0.0013347474159672856,0.0013185065472498536,0.0013016581069678068,0.001284204889088869,0.001266149920411408,0.0012474963441491127,0.0012282476527616382,0.0012084073387086391,0.0011879794765263796,0.0011669682571664453,0.001145377871580422,0.0011232129763811827,0.0011004784610122442,0.0010771792149171233,0.0010533208260312676,0.0010289084166288376,0.0010039480403065681,0.0009784456342458725,0.0009524073102511466,0.0009258395875804126,0.0008987490436993539,0.0008711426635272801,0.0008430274901911616,0.0008144108578562737,0.0007853003335185349,0.0007557037170045078,0.0007256289827637374,0.0006950843380764127,0.000664078164845705,0.0006326191942207515,0.0006007162155583501,0.0005683783092536032,0.000535614846739918,0.0005024350830353796,0.00046884885523468256,0.00043486602953635156,0.0004004966758657247,0.00036575106787495315,0.00033063971204683185,0.0002951732312794775,0.0002593625395093113,0.00022321863798424602,0.0001867527753347531,0.00014997638936620206,0.00011290105612715706,7.553855539299548e-05,3.7900827010162175e-05,-4.743707105062978e-19,-3.815164745901711e-05,-7.654167711734772e-05,-0.00011515745427459478,-0.00015398621326312423,-0.0001930150465341285,-0.0002322308428119868,-0.00027162046171724796,-0.0003111703845206648,-0.00035086722346022725,-0.0003906972997356206,-0.0004306468181312084,-0.0004707018961198628,-0.0005108484183438122,-0.0005510722985491157,-0.0005913592758588493,-0.0006316948565654457,-0.0006720646633766592,-0.0007124539697542787,-0.000752848107367754,-0.0007932322332635522,-0.0008335914462804794,-0.0008739108452573419,-0.000914175296202302,-0.0009543695487082005,-0.0009944784687831998,-0.0010344866896048188,-0.0010743788443505764,-0.0011141394497826695,-0.0011537530226632953,-0.0011932040797546506,-0.0012324769049882889,-0.0012715558987110853,-0.0013104253448545933,-0.0013490695273503661,-0.0013874727301299572,-0.001425619120709598,-0.0014634927501901984,-0.0015010781353339553,-0.0015383590944111347,-0.001575320027768612,-0.0016119448700919747,-0.0016482179053127766,-0.0016841231845319271,-0.0017196449916809797,-0.0017547676106914878,-0.0017894749762490392,-0.001823751605115831,-0.0018575816648080945,-0.0018909494392573833,-0.0019238392123952508,-0.001956235384568572,-0.0019881227053701878,-0.0020194852259010077,-0.0020503078121691942,-0.0020805750973522663,-0.002110271481797099,-0.0021393822971731424,-0.002167891710996628,-0.0021957852877676487,-0.0022230478934943676,-0.0022496646270155907,-0.0022756203543394804,-0.0023009011056274176,-0.0023254919797182083,-0.0023493783082813025,-0.0023725461214780807,-0.002394981449469924,-0.002416669623926282,-0.0024375971406698227,-0.0024577504955232143,-0.0024771152529865503,-0.002495678374543786,-0.0025134270545095205,-0.0025303468573838472,-0.002546426374465227,-0.0025616514030843973,-0.002576009836047888,-0.002589489333331585,-0.0026020773220807314,-0.002613761695101857,-0.002624530578032136,-0.0026343720965087414,-0.0026432753074914217,-0.0026512283366173506,-0.002658219775184989,-0.002664239378646016,-0.0026692759711295366,-0.0026733195409178734,-0.0026763593778014183,-0.0026783854700624943,-0.002679388504475355,-0.00267935823649168,-0.0026782858185470104,-0.0026761621702462435,-0.002672977978363633,-0.0026687253266572952,-0.0026633956003934145,-0.0026569801848381758,-0.002649471862241626,-0.0026408631820231676,-0.0026311464607715607,-0.002620314946398139,-0.002608361653983593,-0.0025952800642699003,-0.0025810645893216133,-0.002565708477050066,-0.0025492068380117416,-0.002531553851440549,-0.002512744627892971,-0.002492774510756135,-0.0024716388434171677,-0.0024493334349244833,-0.0024258545599877834,-0.002401198958978057,-0.002375362440943718,-0.0023483429104089737,-0.002320137806236744,-0.0022907438687980175,-0.002260159933939576,-0.0022283841390162706,-0.0021954146213829517,-0.0021612506825476885,-0.00212589162401855,-0.0020893369801342487,-0.002051586052402854,-0.002012640004977584,-0.001972498372197151,-0.0019311626674607396,-0.0018886339385062456,-0.0018449135823175311,-0.0018000033451244235,-0.0017539055552333593,-0.0017066225409507751,-0.0016581573290750384,-0.001608512713573873,-0.0015576924197375774,-0.0015057000564411283,-0.001452539931051433,-0.0013982162345200777,-0.0013427339727059007,-0.0012860980350524187,-0.0012283140094950795,-0.0011693876003846526,-0.0011093249777331948,-0.0010481324279680848,-0.0009858165867626667,-0.0009223847882822156,-0.0008578442502766848,-0.0007922026561573148,-0.0007254680385813117,-0.0006576487794518471,-0.0005887536099180579,-0.0005187913193367422,-0.0004477713955566287,-0.0003757033555302769,-0.0003025971818715334,-0.0002284630318172276,-0.000153311513713561,-7.715344690950587e-05,4.842922766647768e-19,7.813736738171428e-05,0.00015724690456409007,0.00023731654800940305,0.0003183339140377939,0.00040028642979450524,0.00048316107131540775,0.0005669446545653045,0.0006516237044706941,0.0007371843094006181,0.0008236125577241182,0.000910894013941288,0.0009990140097215772,0.0010879577603191137,0.0011777100153267384,0.001268255291506648,0.0013595782220363617,0.0014516625087708235,0.001544492319226265,0.0016380507731810212,0.0017323214560747147,0.0018272874876856804,0.0019229315221309662,0.0020192365627735853,0.002116184448823333,0.0022137577179819345,0.0023119382094591856,0.0024107075296342373,0.002510047284886241,0.0026099388487637043,0.0027103631291538477,0.002811300801113248,0.002912733471021056,0.0030146408826112747,0.0031170034781098366,0.003219801699742675,0.0033230152912437916,0.003426623996347189,0.003530607558786869,0.003634945722296834,0.003739617532119155,0.003844602033495903,0.003949879202991724,0.0040554264560341835,0.004161223769187927,0.0042672487907111645,0.004373481031507254,0.004479898605495691,0.004586479626595974,0.0046932026743888855,0.004800045397132635,0.004906985908746719,0.0050140018574893475,0.0051210722886025906,0.005228173453360796,0.00533528346568346,0.00544238043949008,0.005549441557377577,0.00565644446760416,0.0057633668184280396,0.0058701857924461365,0.005976878572255373,0.006083422806113958,0.0061897956766188145,0.0062959748320281506,0.0064019374549388885,0.006507660262286663,0.006613121367990971,0.006718297488987446,0.006823166273534298,0.006927705369889736,0.007031891494989395,0.007135702297091484,0.007239115424454212,0.007342108059674501,0.007444657851010561,0.0075467424467206,0.007648339495062828,0.007749426178634167,0.0078499810770154,0.007949982769787312,0.008049406111240387,0.008148232474923134,0.008246438577771187,0.00834400299936533,0.008440903387963772,0.008537118323147297,0.008632626384496689,0.00872740801423788,0.008821440860629082,0.008914702571928501,0.009007173590362072,0.009098833426833153,0.009189660660922527,0.009279636666178703,0.00936873909085989,0.00945694837719202,0.009544244036078453,0.009630609303712845,0.00971602089703083,0.009800462052226067,0.009883913211524487,0.009966352954506874,0.010047766380012035,0.010128132998943329,0.010207434184849262,0.010285652242600918,0.010362770408391953,0.010438770055770874,0.01051363255828619,0.010587343946099281,0.010659884661436081,0.01073123887181282,0.010801391676068306,0.010870324447751045,0.010938023217022419,0.011004472151398659,0.011069654487073421,0.011133556254208088,0.011196164414286613,0.011257462203502655,0.011317437514662743,0.011376073583960533,0.011433359235525131,0.011489280499517918,0.011543825268745422,0.011596979573369026,0.011648731306195259,0.011699069291353226,0.011747981421649456,0.01179545745253563,0.011841483414173126,0.01188605278730]'
    type: fcc
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: '[9.446010153624229e-06,9.157650310953613e-06,8.865617928677239e-06,8.570017598685808e-06,8.270954822364729e-06,7.968534191604704e-06,7.662864845769946e-06,7.35405728846672e-06,7.042220204311889e-06,6.727465915901121e-06,6.409906291082734e-06,6.089655471441802e-06,5.7668275985633954e-06,5.441539087769343e-06,5.11390635438147e-06,4.784047177963657e-06,4.452080247574486e-06,4.118124707019888e-06,3.782300836974173e-06,3.4447296002326766e-06,3.1055326417117612e-06,2.7648325158224907e-06,2.4227522317232797e-06,2.0794154806935694e-06,1.734946295073314e-06,1.3894696166971698e-06,1.0431108421471436e-06,6.959954816920799e-07,3.4824967087843106e-07,-3.9120615266597535e-20,-3.4862677011915366e-07,-6.97503594437876e-07,-1.0465030300110811e-06,-1.395497633893683e-06,-1.7443597926103394e-06,-2.0929614947817754e-06,-2.441174956402392e-06,-2.7888727345271036e-06,-3.1359263630292844e-06,-3.4822080579033354e-06,-3.827590717264684e-06,-4.1719458749867044e-06,-4.515146883932175e-06,-4.857066869590199e-06,-5.197578502702527e-06,-5.536554908758262e-06,-5.873870122741209e-06,-6.209399543877225e-06,-6.543015842908062e-06,-6.874595783301629e-06,-7.204014309536433e-06,-7.531148185080383e-06,-7.85587417340139e-06,-8.178069947462063e-06,-8.497612725477666e-06,-8.814383363642264e-06,-9.128260899160523e-06,-9.439125278731808e-06,-9.74685917753959e-06,-1.0051345270767342e-05,-1.035246441460913e-05,-1.0650102922227234e-05,-1.0944148016278632e-05,-1.1234482371946797e-05,-1.1520996849867515e-05,-1.1803578672697768e-05,-1.208211779157864e-05,-1.235650597664062e-05,-1.26266368170036e-05,-1.2892402082798071e-05,-1.315369809162803e-05,-1.3410420251602773e-05,-1.3662468518305104e-05,-1.3909741937823128e-05,-1.4152139556244947e-05,-1.4389566786121577e-05,-1.4621925402025227e-05,-1.4849123544991016e-05,-1.507106571807526e-05,-1.5287663700291887e-05,-1.5498824723181315e-05,-1.570446511323098e-05,-1.590449937793892e-05,-1.6098838386824355e-05,-1.6287407561321743e-05,-1.6470121408929117e-05,-1.6646903532091528e-05,-1.681767935224343e-05,-1.6982372471829876e-05,-1.7140911950264126e-05,-1.729322502797004e-05,-1.7439244402339682e-05,-1.7578906408743933e-05,-1.7712145563564263e-05,-1.7838900021160953e-05,-1.7959111573873088e-05,-1.807272019505035e-05,-1.8179674952989444e-05,-1.8279914002050646e-05,-1.837339914345648e-05,-1.846007398853544e-05,-1.8539891243563034e-05,-1.861281634774059e-05,-1.867879655037541e-05,-1.873780092864763e-05,-1.8789789464790374e-05,-1.8834727598004974e-05,-1.8872588043450378e-05,-1.8903334421338513e-05,-1.8926946722785942e-05,-1.894339766295161e-05,-1.8952663594973274e-05,-1.8954728147946298e-05,-1.8949574950966053e-05,-1.893718945211731e-05,-1.891755709948484e-05,-1.8890670617111027e-05,-1.8856524548027664e-05,-1.8815111616277136e-05,-1.8766437278827652e-05,-1.8710496078711003e-05,-1.8647291653905995e-05,-1.8576836737338454e-05,-1.8499134966987185e-05,-1.841420089476742e-05,-1.832204725360498e-05,-1.8222688595415093e-05,-1.8116152205038816e-05,-1.800245081540197e-05,-1.788161534932442e-05,-1.775367127265781e-05,-1.7618649508222006e-05,-1.7476582797826268e-05,-1.7327505702269264e-05,-1.7171456420328468e-05,-1.700847496977076e-05,-1.683860318735242e-05,-1.666188836679794e-05,-1.647838143981062e-05,-1.6288127881125547e-05,-1.6091184079414234e-05,-1.5887608242337592e-05,-1.567745493957773e-05,-1.546078419778496e-05,-1.5237666048051324e-05,-1.5008158698037732e-05,-1.4772338545299135e-05,-1.4530270163959358e-05,-1.4282029042078648e-05,-1.4027692486706655e-05,-1.3767337804893032e-05,-1.3501045032171533e-05,-1.3228897842054721e-05,-1.2950983546033967e-05,-1.2667385817621835e-05,-1.2378198334772605e-05,-1.2083512046956457e-05,-1.178341972263297e-05,-1.1478022315714043e-05,-1.1167417142132763e-05,-1.0851702427316923e-05,-1.0530985491641331e-05,-1.0205370017501991e-05,-9.874964234768413e-06,-9.53987728280481e-06,-9.200221029459499e-06,-8.856109161570203e-06,-8.507656275469344e-06,-8.154982424457557e-06,-7.798204933351371e-06,-7.437445219693473e-06,-7.072826520015951e-06,-6.704474344587652e-06,-6.3325142036774196e-06,-5.9570761550276075e-06,-5.578288437391166e-06,-5.196283382247202e-06,-4.811193775822176e-06,-4.4231551328266505e-06,-4.032302967971191e-06,-3.6387752970767906e-06,-3.2427110454591457e-06,-2.84425073004968e-06,-2.4435360046481946e-06,-2.040710114670219e-06,-1.6359169876523083e-06,-1.2293022564335843e-06,-8.210126338781265e-07,-4.1119562865787884e-07,-3.084972356338504e-20,4.124245833736495e-07,8.259274295596697e-07,1.2403571645336342e-06,1.6555612774027395e-06,2.0713866888399934e-06,2.4876796942407964e-06,2.9042853384453338e-06,3.321049007354304e-06,3.737814495252678e-06,4.154425823799102e-06,4.570726105157519e-06,4.986557996744523e-06,5.401764155976707e-06,5.816187240270665e-06,6.229668997548288e-06,6.642050266236765e-06,7.053173703752691e-06,7.462880603270605e-06,7.8710127127124e-06,8.277411325252615e-06,8.68191727931844e-06,9.084374141821172e-06,9.484621841693297e-06,9.882504855340812e-06,1.027786493068561e-05,1.0670544725144282e-05,1.1060386896133423e-05,1.144723682955373e-05,1.1830939001811203e-05,1.2211336979817133e-05,1.2588277968461625e-05,1.2961607353645377e-05,1.3331174159247894e-05,1.3696823771169875e-05,1.4058408851269633e-05,1.441577660443727e-05,1.4768778783036396e-05,1.5117267139430624e-05,1.546109706396237e-05,1.5800120308995247e-05,1.6134192264871672e-05,1.6463172869407572e-05,1.6786918422440067e-05,1.7105288861785084e-05,1.7418145944247954e-05,1.7725355064612813e-05,1.8026772522716783e-05,1.832227462728042e-05,1.8611721316119656e-05,1.889498707896564e-05,1.9171940948581323e-05,1.9442455595708452e-05,1.9706407329067588e-05,1.996367245737929e-05,2.021413092734292e-05,2.045766268565785e-05,2.0694153135991655e-05,2.092348768201191e-05,2.1145549908396788e-05,2.1360236132750288e-05,2.156743357772939e-05,2.176703856093809e-05,2.1958951037959196e-05,2.2143067326396704e-05,2.2319291019812226e-05,2.248752753075678e-05,2.2647682271781377e-05,2.2799666112405248e-05,2.294339174113702e-05,2.3078773665474728e-05,2.320573548786342e-05,2.332418989681173e-05,2.3434069589711726e-05,2.353529453102965e-05,2.362779741815757e-05,2.3711510948487557e-05,2.3786371457390487e-05,2.3852315280237235e-05,2.39092896663351e-05,2.395723458903376e-05,2.399609911662992e-05,2.4025839593377896e-05,2.4046405087574385e-05,2.4057757400441915e-05,2.4059854695224203e-05,2.4052664230111986e-05,2.4036151444306597e-05,2.4010290871956386e-05,2.3975053409230895e-05,2.393042086623609e-05,2.3876373234088533e-05,2.3812895960872993e-05,2.373997813265305e-05,2.365760701650288e-05,2.3565786250401288e-05,2.3464508558390662e-05,2.3353777578449808e-05,2.3233602405525744e-05,2.3103992134565488e-05,2.296495767950546e-05,2.2816517230239697e-05,2.2658690795651637e-05,2.2491505660582334e-05,2.231498365290463e-05,2.2129162971396e-05,2.19340727198869e-05,2.1729756554123014e-05,2.151625267288182e-05,2.1293612007866614e-05,2.1061878214823082e-05,2.0821107682422735e-05,2.0571358618326485e-05,2.0312689230195247e-05,2.0045165001647547e-05,1.9768851416301914e-05,1.948382123373449e-05,1.919015085150022e-05,1.8887914848164655e-05,1.8577196897240356e-05,1.82580879481975e-05,1.793066803656984e-05,1.7595035387785174e-05,1.725128458929248e-05,1.6899512047530152e-05,1.6539826901862398e-05,1.6172331015695818e-05,1.579713716637343e-05,1.541435813123826e-05,1.5024105778138619e-05,1.4626504707848653e-05,1.42216767926584e-05,1.3809746633342002e-05,1.3390847016125917e-05,1.2965108908247203e-05,1.253266691492172e-05,1.2093662007828243e-05,1.164823606814025e-05,1.1196531886525918e-05,1.0738700439105742e-05,1.0274891792505514e-05,9.805258741835132e-06,9.329958629678003e-06,8.849152436596341e-06,8.363000233657658e-06,7.871668458392378e-06,7.375323548330925e-06,6.8741373979719356e-06,6.368282356561394e-06,5.857933501829393e-06,5.3432690947374795e-06,4.824468760489253e-06,4.30171485277242e-06,3.7751931358798174e-06,3.2450898288516328e-06,2.7115943339595105e-06,2.1748983272118494e-06,1.6351943941117497e-06,1.0926784170806059e-06,5.475473017213517e-07,-5.475538866900959e-20,-5.497626034411951e-07,-1.1015382597179268e-06,-1.6551225598959718e-06,-2.2103101855464047e-06,-2.7668936581903836e-06,-3.3246647035412025e-06,-3.883413228322752e-06,-4.442928457137896e-06,-5.00299802297377e-06,-5.563407739828108e-06,-6.123943421698641e-06,-6.684390427835751e-06,-7.244531843753066e-06,-7.804150300216861e-06,-8.363027518498711e-06,-8.920946129364893e-06,-9.477685125602875e-06,-1.0033028047473636e-05,-1.058675206877524e-05,-1.1138638001284562e-05,-1.168846483778907e-05,-1.2236012480570935e-05,-1.2781059012922924e-05,-1.3323384337127209e-05,-1.3862769264960662e-05,-1.4398989151231945e-05,-1.4931828445696738e-05,-1.5461064322153106e-05,-1.598648123035673e-05,-1.650785270612687e-05,-1.7024965927703306e-05,-1.7537602616357617e-05,-1.804554631235078e-05,-1.854857873695437e-05,-1.9046488887397572e-05,-1.9539056665962562e-05,-2.0026074707857333e-05,-2.0507328372332267e-05,-2.098261029459536e-05,-2.1451705833896995e-05,-2.1914411263423972e-05,-2.2370522856363095e-05,-2.281983324792236e-05,-2.326213871128857e-05,-2.369724097661674e-05,-2.4124939955072477e-05,-2.45450391958002e-05,-2.495734406693373e-05,-2.5361661755596288e-05,-2.5757801267900504e-05,-2.614557342894841e-05,-2.652479633979965e-05,-2.689528264454566e-05,-2.725685408222489e-05,-2.7609330572886392e-05,-2.7952541131526232e-05,-2.8286309316172265e-05,-2.861046596080996e-05,-2.8924843718414195e-05,-2.922928069892805e-05,-2.952361865027342e-05,-2.9807695682393387e-05,-3.008136263815686e-05,-3.0344463084475137e-05,-3.059684968320653e-05,-3.0838389648124576e-05,-3.106892836512998e-05,-3.128834214294329e-05,-3.149649273836985e-05,-3.1693245546193793e-05,-3.187848051311448e-05,-3.205207394785248e-05,-3.2213916711043566e-05,-3.236388511140831e-05,-3.25018736475613e-05,-3.2627780456095934e-05,-3.2741500035626814e-05,-3.284294143668376e-05,-3.293200643383898e-05,-3.3008604077622294e-05,-3.307266524643637e-05,-3.312409535283223e-05,-3.3162828913191333e-05,-3.318879316793755e-05,-3.320192627143115e-05,-3.3202166378032416e-05,-3.318945164210163e-05,-3.31637347699143e-05,-3.312497210572474e-05,-3.3073123631766066e-05,-3.300814933027141e-05,-3.29300164594315e-05,-3.28387031913735e-05,-3.273418406024575e-05,-3.261644087615423e-05,-3.248547000112012e-05,-3.2341260521207005e-05,-3.218380516045727e-05,-3.201311847078614e-05,-3.182919681421481e-05,-3.163206929457374e-05,-3.142174318782054e-05,-3.119825487374328e-05,-3.0961622542236e-05,-3.071188257308677e-05,-3.044908407900948e-05,-3.0173261620802805e-05,-2.9884475225117058e-05,-2.9582775823655538e-05,-2.926822708104737e-05,-2.894089266192168e-05,-2.860084714484401e-05,-2.8248165108379908e-05,-2.7882933864020742e-05,-2.7505235266289674e-05,-2.7115163902635686e-05,-2.6712819817475975e-05,-2.6298303055227734e-05,-2.5871728212223388e-05,-2.543319897085894e-05,-2.4982844479382038e-05,-2.4520782972103916e-05,-2.4047143597272225e-05,-2.3562060960102826e-05,-2.306567330379039e-05,-2.2558127966476604e-05,-2.2039575924281962e-05,-2.1510162696358748e-05,-2.0970053810742684e-05,-2.0419414795469493e-05,-1.9858405721606687e-05,-1.928720848809462e-05,-1.8705997717916034e-05,-1.8114957129000686e-05,-1.751427407725714e-05,-1.6904139556572773e-05,-1.628475365578197e-05,-1.565631464472972e-05,-1.5019028978713322e-05,-1.4373107660503592e-05,-1.371876169287134e-05,-1.3056213902018499e-05,-1.2385683476168197e-05,-1.1707397788995877e-05,-1.1021589671145193e-05,-1.03284919532598e-05,-9.628344741940964e-06,-8.921388143789954e-06,-8.207870450860355e-06,-7.4880408647004515e-06,-6.762153589079389e-06,-6.030463737261016e-06,-5.293232788972091e-06,-4.5507244976761285e-06,-3.803205345320748e-06,-3.0509449970850255e-06,-2.294216983500519e-06,-1.533296995148703e-06,-7.684642469030223e-07,2.1141150596524758e-19,7.718113010923844e-07,1.546682938169397e-06,2.3243253508553607e-06,3.1044467050378444e-06,3.886753802362364e-06,4.670950147556141e-06,5.456737198983319e-06,6.243814823392313e-06,7.031881978036836e-06,7.820633982191794e-06,8.609766155132093e-06,9.398971997143235e-06,1.0187942280026618e-05,1.0976369594573043e-05,1.1763939255615696e-05,1.2550345672934782e-05,1.3335270523384679e-05,1.4118403669272084e-05,1.4899432244419586e-05,1.5678038835176267e-05,1.645390693738591e-05,1.722672641335521e-05,1.7996175301959738e-05,1.8761944375000894e-05,1.9523713490343653e-05,2.02811679628212e-05,2.1033994926256128e-05,2.1781876057502814e-05,2.2524502128362656e-05,2.3261556634679437e-05,2.3992724891286343e-05,2.4717697669984773e-05,2.5436162104597315e-05,2.614781078591477e-05,2.6852336304727942e-05,2.7549431251827627e-05,2.8238786399015225e-05,2.892010161303915e-05,2.959307676064782e-05,3.0257408070610836e-05,3.091279722866602e-05,3.155894955853e-05,3.2195581297855824e-05,3.2822383218444884e-05,3.343908247188665e-05,3.404538438189775e-05,3.4641016100067645e-05,3.522569022607058e-05,3.5799126635538414e-05,3.636105975601822e-05,3.6911213101120666e-05,3.744932109839283e-05,3.7975129089318216e-05,3.8488360587507486e-05,3.898877548635937e-05,3.947611548937857e-05,3.995012957602739e-05,4.041057400172576e-05,4.085721593583003e-05,4.128981527173892e-05,4.170814645476639e-05,4.21119766542688e-05,4.250108395353891e-05,4.2875257349805906e-05,4.323428220232017e-05,4.357795478426851e-05,4.3906064092880115e-05,4.4218428229214624e-05,4.4514839828480035e-05,4.479512426769361e-05,4.505909964791499e-05,4.530659134616144e-05,4.553742837742902e-05,4.575145067065023e-05,4.594849451677874e-05,4.612842167261988e-05,4.629107206710614e-05,4.643631473300047e-05,4.6564015065087005e-05,4.66740493720863e-05,4.6766297600697726e-05,4.684064333559945e-05,4.689697379944846e-05,4.693520531873219e-05,4.695522875408642e-05,4.6956960431998596e-05,4.6940323954913765e-05,4.690524656325579e-05,4.685165549744852e-05,4.6779496187809855e-05,4.6688717702636495e-05,4.6579265472246334e-05,4.645111403078772e-05,4.630422336049378e-05,4.613857527147047e-05,4.595414793584496e-05,4.5750941353617236e-05,4.552893733489327e-05,4.5288157707545906e-05,4.5028609747532755e-05,4.475031164474785e-05,4.445328886504285e-05,4.413758506416343e-05,4.3803240259876475e-05,4.3450298107927665e-05,4.307882772991434e-05,4.268888005753979e-05,4.2280542402295396e-05,4.1853887523757294e-05,4.140900637139566e-05,4.094598989468068e-05,4.0464947232976556e-05,3.9965987525647506e-05,3.944922718801536e-05,3.8914793549338356e-05,3.836281757685356e-05,3.779344478971325e-05,3.72068170690909e-05,3.660309448605403e-05,3.598244074964896e-05,3.5345019568922e-05,3.469102011877112e-05,3.402061338420026e-05,3.333400673000142e-05,3.263138569309376e-05,3.19129612762481e-05,3.117895539617166e-05,3.042957905563526e-05,2.966506508528255e-05,2.888564813474659e-05,2.809156649163924e-05,2.7283069357508793e-05,2.646041684783995e-05,2.5623865440138616e-05,2.4773687982815318e-05,2.3910153686301783e-05,2.303354995092377e-05,2.2144160539028235e-05,2.1242281945887953e-05,2.0328210666775703e-05,1.9402259567868896e-05,1.8464737877366133e-05,1.7515962099423632e-05,1.6556261471123435e-05,1.5585956134600565e-05,1.4605391697841696e-05,1.3614903764391784e-05,1.2614839761226904e-05,1.1605551662796643e-05,1.0587395081529394e-05,9.560732905811165e-06,8.525930752512068e-06,7.483361059712479e-06,6.433398084482178e-06,5.376424269343261e-06,4.312823421059875e-06,3.2429854854854057e-06,2.1673031369573437e-06,1.0861742794077145e-06,-9.505224184196046e-20,-1.0908149761235109e-06,-2.1858620584680466e-06,-3.2847294733073795e-06,-4.387002263683826e-06,-5.492261607287219e-06,-6.600087090191664e-06,-7.710053978371434e-06,-8.821734809316695e-06,-9.934702575264964e-06,-1.1048523447243497e-05,-1.2162764505774248e-05,-1.3276991921884473e-05,-1.4390765500138514e-05,-1.5503646864090115e-05,-1.6615194908808917e-05,-1.7724965800880454e-05,-1.8832521163858473e-05,-1.9937411707360297e-05,-2.103919723595027e-05,-2.2137424821266904e-05,-2.3231654267874546e-05,-2.4321434466401115e-05,-2.540632340242155e-05,-2.648586996656377e-05,-2.7559628506423905e-05,-2.8627155188587494e-05,-2.968800072267186e-05,-3.0741721275262535e-05,-3.178787665092386e-05,-3.282601755927317e-05,-3.38557074428536e-05,-3.48765061062295e-05,-3.58879697159864e-05,-3.688966535264626e-05,-3.788115645875223e-05,-3.886201011482626e-05,-3.983180795330554e-05,-4.07901025027968e-05,-4.173647903371602e-05,-4.2670522816479206e-05,-4.35917972936295e-05,-4.4499902287498116e-05,-4.539441943052225e-05,-4.627493763109669e-05,-4.714106034953147e-05,-4.799237285624258e-05,-4.882849316345528e-05,-4.9649024731479585e-05,-5.045357102062553e-05,-5.1241760957054794e-05,-5.201320891501382e-05,-5.276754018268548e-05,-5.3504390962189063e-05,-5.4223393817665055e-05,-5.492419586516917e-05,-5.560644422075711e-05,-5.6269793276442215e-05,-5.691390106221661e-05,-5.753844015998766e-05,-5.814307587570511e-05,-5.872748079127632e-05,-5.9291356592439115e-05,-5.983439041301608e-05,-6.035627666278742e-05,-6.085672430344857e-05,-6.133544957265258e-05,-6.179216870805249e-05,-6.222661613719538e-05,-6.263852264964953e-05,-6.302764086285606e-05,-6.339370884234086e-05,-6.373649375746027e-05,-6.405577732948586e-05,-6.435131217585877e-05,-6.462289456976578e-05,-6.48703207843937e-05,-6.509337981697172e-05,-6.529190432047471e-05,-6.54656978440471e-05,-6.561458576470613e-05,-6.573842256329954e-05,-6.583704816875979e-05,-6.591031706193462e-05,-6.595808372367173e-05,-6.598024629056454e-05,-6.597666651941836e-05,-6.594725709874183e-05,-6.589192344108596e-05,-6.581056368304417e-05,-6.570310506504029e-05,-6.556949665537104e-05,-6.540967297041789e-05,-6.522358307847753e-05,-6.50111905997619e-05,-6.477248098235577e-05,-6.450743967434391e-05,-6.421604484785348e-05,-6.389831833075732e-05,-6.355427467497066e-05,-6.31839211564511e-05,-6.27873232588172e-05,-6.236451008589938e-05,-6.191553984535858e-05,-6.144048529677093e-05,-6.09394337516278e-05,-6.0412465245462954e-05,-5.985967436572537e-05,-5.928118116571568e-05,-5.867710569873452e-05,-5.804757893201895e-05,-5.7392739108763635e-05,-5.671274266205728e-05,-5.600776057690382e-05,-5.5277952924370766e-05,-5.452351979329251e-05,-5.37446430826094e-05,-5.2941533795092255e-05,-5.211440657149069e-05,-5.126349424244836e-05,-5.038902600063011e-05,-4.949124559061602e-05,-4.8570422222837806e-05,-4.7626817831769586e-05,-4.666070526582189e-05,-4.5672371925320476e-05,-4.4662119762506336e-05,-4.363025800557807e-05,-4.257709224475548e-05,-4.150296808802523e-05,-4.040820203954354e-05,-3.9293154259212315e-05,-3.815817035501823e-05,-3.7003617762820795e-05,-3.582987483241595e-05,-3.463731627562083e-05,-3.342633863212541e-05,-3.2197345717577264e-05,-3.095073770964518e-05,-2.9686942070838995e-05,-2.8406380806700327e-05,-2.710948683670722e-05,-2.5796707632252946e-05,-2.446849066473078e-05,-2.3125294319470413e-05,-2.1767591533716768e-05,-2.0395847968757153e-05,-1.901055293274112e-05,-1.7612190276850015e-05,-1.6201258404180408e-05,-1.4778262084291782e-05,-1.334370972472243e-05,-1.1898117918462958e-05,-1.0442008715472184e-05,-8.975913260655943e-06,-7.500365882151527e-06,-6.015909093548544e-06,-4.523088591668056e-06,-3.0224575766624184e-06,-1.5145736824706546e-06,-1.5155480398574397e-19,1.5206957186819636e-06,3.0469407192867948e-06,4.578158950607758e-06,6.1137679949752055e-06,7.653182365174871e-06,9.195813618134707e-06,1.0741067853814457e-05,1.2288348443689756e-05,1.3837059668730944e-05,1.5386593076982535e-05,1.693634840194136e-05,1.8485716282157227e-05,2.003408553719055e-05,2.1580846805591136e-05,2.3125381630961783e-05,2.46670788328629e-05,2.6205319954897277e-05,2.773948472167831e-05,2.9268960133777e-05,3.0793122277827933e-05,3.2311352697433904e-05,3.38230311172083e-05,3.532754271873273e-05,3.6824250855715945e-05,3.8312558899633586e-05,3.979183384217322e-05,4.1261471778852865e-05,4.27208433393389e-05,4.4169340981170535e-05,4.5606349885929376e-05,4.703125887317583e-05,4.844347495236434e-05,4.9842376029118896e-05,5.1227361836936325e-05,5.2597835747292265e-05,5.395320840761997e-05,5.529287955141626e-05,5.66162598261144e-05,5.792277443106286e-05,5.921183037571609e-05,6.0482863773358986e-05,6.173529254738241e-05,6.29685673629865e-05,6.418210978154093e-05,6.537537410622463e-05,6.654781464021653e-05,6.769889296265319e-05,6.882805610075593e-05,6.993478018557653e-05,7.101854862412438e-05,7.207883754745126e-05,7.311514491448179e-05,7.412696140818298e-05,7.511380681535229e-05,7.607517909491435e-05,7.701059803366661e-05,7.791961979819462e-05,7.880175689933822e-05,7.965656550368294e-05,8.048360177781433e-05,8.128244371619076e-05,8.205264748539776e-05,8.279381290776655e-05,8.350552525371313e-05,8.418739162152633e-05,8.483903366141021e-05,8.546006574761122e-05,8.605013135820627e-05,8.660888852318749e-05,8.713595889275894e-05,8.763105870457366e-05,8.809382416075096e-05,8.852397877490148e-05,8.892120968084782e-05,8.928524039220065e-05,8.961579442257062e-05,8.991260983748361e-05,9.017543925438076e-05,9.040405711857602e-05,9.05982160475105e-05,9.075771959032863e-05,9.088238584809005e-05,9.097200381802395e-05,9.10264061531052e-05,9.10454400582239e-05,9.102896729018539e-05,9.097684232983738e-05,9.088895603781566e-05,9.076521382667124e-05,9.060548472916707e-05,9.04097396414727e-05,9.017789125209674e-05,8.990989590529352e-05,8.960570994531736e-05,8.92653115442954e-05,8.888871525414288e-05,8.847590652294457e-05,8.802690717857331e-05,8.75417681527324e-05,8.70205185492523e-05,8.646325295558199e-05,8.587002957938239e-05,8.524095028406009e-05,8.45761169330217e-05,8.387564594158903e-05,8.31396973808296e-05,8.236840221798047e-05,8.156193507602438e-05,8.072047057794407e-05,7.984421245055273e-05,7.893336442066357e-05,7.798815931892022e-05,7.700882270000875e-05,7.599560922244564e-05,7.494880264857784e-05,7.386866491287947e-05,7.27554943296127e-05,7.160961831687018e-05,7.043133518891409e-05,6.92209941917099e-05,6.797895184718072e-05,6.670557195320725e-05,6.540122558362782e-05,6.406632019206882e-05,6.270125595619902e-05,6.130644032964483e-05,5.988232805975713e-05,5.8429348428035155e-05,5.6947967095766217e-05,5.5438657000195235e-05,5.390190563048236e-05,5.233820775174536e-05,5.074807631899603e-05,4.913203156320378e-05,4.7490608267253265e-05,4.582436304190196e-05,4.413383430801332e-05,4.2419607780175284e-05,4.06822728109546e-05,3.8922400563023984e-05,3.714061313075945e-05,3.533752169460058e-05,3.351374471094459e-05,3.166993337799795e-05,2.980672252306249e-05,2.7924774258281104e-05,2.602475433377549e-05,2.4107339413603768e-05,2.217321889474988e-05,2.0223083993187174e-05,1.8257638657814823e-05,1.627759775146842e-05,1.4283679774962366e-05,1.227661869052099e-05,1.0257147550873924e-05,8.226014870160725e-06,6.183969617268303e-06,4.131773948756745e-06,2.070192749670241e-06,-1.5524623964092964e-19,-2.078025090668234e-06,-4.1630978557805065e-06,-6.2544268075725995e-06,-8.351215001312084e-06,-1.0452660717419349e-05,-1.2557958143588621e-05,-1.4666296920040622e-05,-1.6776861230027862e-05,-1.888882979983464e-05,-2.1001384084229358e-05,-2.3113694624044e-05,-2.522493014112115e-05,-2.733426481427159e-05,-2.9440860089380294e-05,-3.154388105031103e-05,-3.364248914294876e-05,-3.573585127014667e-05,-3.782311614486389e-05,-3.9903443393995985e-05,-4.197600355837494e-05,-4.40399453509599e-05,-4.6094428398646414e-05,-4.8138612328330055e-05,-5.017166040488519e-05,-5.219272497924976e-05,-5.4200976592255756e-05,-5.619558214675635e-05,-5.8175704907625914e-05,-6.014051177771762e-05,-6.208918784977868e-05,-6.402088183676824e-05,-6.593480793526396e-05,-6.78301221341826e-05,-6.970603135414422e-05,-7.15617134119384e-05,-7.339638250414282e-05,-7.520921644754708e-05,-7.699944399064407e-05,-7.876627205405384e-05,-8.05089293862693e-05,-8.22266229079105e-05,-8.391860319534317e-05,-8.558411354897544e-05,-8.722239726921543e-05,-8.883271220838651e-05,-9.041433077072725e-05,-9.196650353260338e-05,-9.348853200208396e-05,-9.497971768723801e-05,-9.643934026826173e-05,-9.786672308109701e-05,-9.92611821857281e-05,-0.00010062205547001213,-0.00010194867354584858,-0.00010324041068088263,-0.00010449659748701379,-0.00010571665916359052,-0.00010689994815038517,-0.00010804587509483099,-0.00010915385792031884,-0.00011022329999832436,-0.00011125367018394172,-0.00011224442278034985,-0.00011319499026285484,-0.00011410489241825417,-0.00011497358354972675,-0.0001158005979959853,-0.00011658545554382727,-0.00011732769053196535,-0.00011802685185102746,-0.0001186825247714296,-0.00011929427273571491,-0.00011986169556621462,-0.00012038441491313279,-0.00012086205970263109,-0.00012129429524065927,-0.00012168076500529423,-0.00012202116340631619,-0.00012231517757754773,-0.00012256251648068428,-0.00012276294000912458,-0.00012291617167647928,-0.00012302199320401996,-0.0001230801863130182,-0.0001230905472766608,-0.00012305291602388024,-0.0001229671179316938,-0.0001228330220328644,-0.00012265048280823976,-0.00012241941294632852,-0.00012213973968755454,-0.0001218113538925536,-0.0001214342555613257,-0.00012100837921025231,-0.00012053373939124867,-0.00012001032882835716,-0.00011943817662540823,-0.00011881733371410519,-0.00011814787285402417,-0.00011742987408069894,-0.00011666343925753608,-0.00011584870662773028,-0.00011498579260660335,-0.00011407489364501089,-0.0001131161698140204,-0.00011210982484044507,-0.00011105609883088619,-0.00010995522461598739,-0.00010880745685426518,-0.00010761307930806652,-0.00010637238301569596,-0.00010508570267120376,-0.00010375337296864018,-0.00010237573587801307,-0.00010095318430103362,-9.948611113941297e-05,-9.797492384677753e-05,-9.642005898058414e-05,-9.48219676502049e-05,-9.318112279288471e-05,-9.14979973458685e-05,-8.977312973001972e-05,-8.800702198641375e-05,-8.620021981187165e-05,-8.435329800704494e-05,-8.246681682066992e-05,-8.054138015722856e-05,-7.857760647311807e-05,-7.657612150069326e-05,-7.453758735209703e-05,-7.246265158755705e-05,-7.035200542304665e-05,-6.820633279858157e-05,-6.602638313779607e-05,-6.381285493262112e-05,-6.156650488264859e-05,-5.928809696342796e-05,-5.697840970242396e-05,-5.4638228903058916e-05,-5.226836583460681e-05,-4.986964268027805e-05,-4.7442899813177064e-05,-4.498898488236591e-05,-4.250875281286426e-05,-4.000308399554342e-05,-3.7472880649147555e-05,-3.491903771646321e-05,-3.234246833017096e-05,-2.9744098355877213e-05,-2.712487730605062e-05,-2.448574741720222e-05,-2.182767457270529e-05,-1.915163011290133e-05,-1.6458599930047058e-05,-1.3749575373367406e-05,-1.1025560525013134e-05,-8.287570381071419e-06,-5.536624485102948e-06,-2.7737548862205585e-06,6.9345078821067425e-19,2.7835928904096363e-06,5.575969225901645e-06,8.37606694403803e-06,1.1182818525412586e-05,1.3995148037793115e-05,1.6811976820463315e-05,1.9632216208265163e-05,2.245477298856713e-05,2.5278555767727084e-05,2.8102460419177078e-05,3.092538099735975e-05,3.374621883267537e-05,3.656384797068313e-05,3.9377166103804484e-05,4.218505637254566e-05,4.4986391003476456e-05,4.778006405103952e-05,5.056494410382584e-05,5.3339921578299254e-05,5.610386506305076e-05,5.88556649745442e-05,6.159419717732817e-05,6.431833025999367e-05,6.702697282889858e-05,6.97190043865703e-05,7.239329715957865e-05,7.50487670302391e-05,7.768427894916385e-05,8.0298756074626e-05,8.289110701298341e-05,8.546021854272112e-05,8.800501382211223e-05,9.052440873347223e-05,9.301733371103182e-05,9.548272646497935e-05,9.791951742954552e-05,0.00010032664431491867,0.0001027030884870328,0.00010504779493203387,0.00010735973773989826,0.00010963790555251762,0.00011188127973582596,0.00011408887075958773,0.00011625968181760982,0.00011839274520752952,0.00012048707867506891,0.0001225417508976534,0.00012455580872483552,0.00012652832083404064,0.0001284583704546094,0.0001303450553677976,0.0001321875024586916,0.00013398483861237764,0.0001357361616101116,0.00013744068564847112,0.00013909752306062728,0.0001407059171469882,0.00014226502389647067,0.000143774101161398,0.00014523236313834786,0.00014663906767964363,0.00014799348718952388,0.00014929492317605764,0.0001505426480434835,0.0001517360215075314,0.00015287440328393131,0.0001539571094326675,0.00015498354332521558,0.0001559531519887969,0.00015686529513914138,0.00015771944890730083,0.00015851508942432702,0.00015925169282127172,0.00015992874978110194,0.00016054582374636084,0.0001611024490557611,0.0001615982037037611,0.00016203266568481922,0.0001624055003048852,0.00016271630011033267,0.00016296477406285703,0.0001631505583645776,0.00016327339108102024,0.0001633330393815413,0.00016332922677975148,0.00016326174954883754,0.0001631304039619863,0.00016293504450004548,0.00016267549654003233,0.00016235167277045548,0.00016196347132790834,0.00016151081945281476,0.0001609936443855986,0.00016041198978200555,0.00015976581198628992,0.00015905516920611262,0.00015828009054530412,0.00015744069241918623,0.00015653707669116557,0.00015556934522464871,0.00015453770174644887,0.00015344230632763356,0.00015228336269501597,0.0001510611327830702,0.00014977584942243993,0.0001484278473071754,0.00014701737381983548,0.00014554482186213136,0.00014401052612811327,0.00014241489407140762,0.00014075830404181033,0.0001390412508044392,0.00013726417091675103,0.00013542755914386362,0.00013353191025089473,0.00013157779176253825,0.0001295657712034881,0.0001274964160984382,0.00012537035217974335,0.0001231882197316736,0.00012095068086637184,0.00011865841952385381,0.0001163121487479657,0.00011391259613446891,0.00011146052565891296,0.00010895671584876254,0.00010640195978339761,0.00010379710147390142,0.00010114297765539959,9.844046871876344e-05,9.569044777890667e-05,9.28938461584039e-05,9.005159517982975e-05,8.716465526958928e-05,8.423399413004518e-05,8.126060856739059e-05,7.824552449164912e-05,7.518977508880198e-05,7.209441537270322e-05,6.896052946103737e-05,6.578919419553131e-05,6.258155190153047e-05,5.93386976106558e-05,5.6061806390061975e-05,5.275203147903085e-05,4.941055885865353e-05,4.6038585423957556e-05,4.2637326259864494e-05,3.920801464118995e-05,3.5751891118707135e-05,3.227021807106212e-05,2.8764272428816184e-05,2.523533839848824e-05,2.1684716557501815e-05,1.8113723854185082e-05,1.4523683603329118e-05,1.0915935490629636e-05,7.291831025213469e-06,3.652728764791391e-06,-2.2821969969005147e-19,-3.664973974082386e-06,-7.340802312683081e-06,-1.102608712244546e-05,-1.4719420505571179e-05,-1.8419385014567524e-05,-2.2124560928205028e-05,-2.5833518520812504e-05,-2.9544817152782343e-05,-3.325702346046455e-05,-3.69686858903151e-05,-4.0678351069800556e-05,-4.438456744537689e-05,-4.8085876187542453e-05,-5.17808148288168e-05,-5.546792090171948e-05,-5.9145728300791234e-05,-6.2812767282594e-05,-6.64675681036897e-05,-7.010867557255551e-05,-7.373461266979575e-05,-7.734390237601474e-05,-8.093510405160487e-05,-8.450674795312807e-05,-8.805735706118867e-05,-9.158549073617905e-05,-9.508970833849162e-05,-9.856853284873068e-05,-0.00010202054545516148,-0.0001054443055181764,-0.00010883836512221023,-0.00011220133455935866,-0.00011553176591405645,-0.00011882826220244169,-0.00012208943371661007,-0.00012531387619674206,-0.00012850022176280618,-0.00013164710253477097,-0.00013475313608068973,-0.00013781699817627668,-0.00014083732094150037,-0.0001438128383597359,-0.00014674219710286707,-0.00014962411660235375,-0.00015245730173774064,-0.00015524050104431808,-0.00015797244850546122,-0.00016065192176029086,-0.00016327771299984306,-0.0001658485853113234,-0.00016836338909342885,-0.0001708209456410259,-0.0001732200908008963,-0.00017555973317939788,-0.00017783872317522764,-0.00018005598394665867,-0.0001822104532038793,-0.00018430108320899308,-0.00018632685532793403,-0.0001882867654785514,-0.0001901798095786944,-0.00019200504175387323,-0.00019376153068151325,-0.0001954483741428703,-0.00019706466991920024,-0.0001986095739994198,-0.00020008219871670008,-0.00020148178737144917,-0.00020280755416024476,-0.0002040586987277493,-0.00020523453713394701,-0.0002063343272311613,-0.00020735739963129163,-0.00020830311405006796,-0.00020917083020322025,-0.00020995996601413935,-0.00021066995395813137,-0.00021130024106241763,-0.0002118503616657108,-0.00021231982100289315,-0.00021270816796459258,-0.00021301496599335223,-0.00021323985129129142,-0.00021338248916435987,-0.00021344251581467688,-0.0002134196402039379,-0.000213313614949584,-0.00021312423632480204,-0.0002128512569470331,-0.00021249454584904015,-0.00021205392840784043,-0.0002115293755196035,-0.00021092074166517705,-0.0002102280268445611,-0.00020945124560967088,-0.00020859039796050638,-0.0002076455275528133,-0.0002066167799057439,-0.00020550427143462002,-0.00020430810400284827,-0.0002030285686487332,-0.0002016658108914271,-0.000200220150873065,-0.00019869182142429054,-0.0001970812154468149,-0.00019538866763468832,-0.00019361454178579152,-0.00019175931811332703,-0.00018982341862283647,-0.0001878073380794376,-0.0001857116149039939,-0.0001835368457250297,-0.00018128355441149324,-0.00017895238124765456,-0.00017654402472544461,-0.00017405912512913346,-0.00017149843915831298,-0.0001688627089606598,-0.00016615269123576581,-0.00016336922999471426,-0.00016051319835241884,-0.00015758542576804757,-0.00015458684356417507,-0.00015151839761529118,-0.00014838103379588574,-0.0001451757998438552,-0.0001419036852894351,-0.0001385657669743523,-0.00013516312174033374,-0.00013169687008485198,-0.00012816819071304053,-0.00012457820412237197,-0.00012092815450159833,-0.00011721925693564117,-0.0001134527483372949,-0.00010962993837893009,-0.00010575212945695966,-0.00010182066762354225,-9.783689165487885e-05,-9.380218398291618e-05,-8.971797797130421e-05,-8.558567787986249e-05,-8.140677527990192e-05,-7.718271081103012e-05,-7.291501970030367e-05,-6.860518624307588e-05,-6.425479659810662e-05,-5.9865396906388924e-05,-5.543856605072506e-05,-5.097592293168418e-05,-4.647908644983545e-05,-4.194970097159967e-05,-3.7389421777334064e-05,-3.279993688920513e-05,-2.8182937967358157e-05,-2.3540131223853678e-05,-1.887325015559327e-05,-1.4184031897457317e-05,-9.474236321693752e-06,-4.745631031255471e-06,2.668340674970695e-19,4.760862339026062e-06,9.535148819850292e-06,1.43210427268059e-05,1.9116712792310864e-05,2.392032547504641e-05,2.8730035410262644e-05,3.3543976314831525e-05,3.8360296457540244e-05,4.3177125917281955e-05,4.79925874969922e-05,5.280480036162771e-05,5.761186912423e-05,6.24119202257134e-05,6.720305100316182e-05,7.198336970759556e-05,7.67509700381197e-05,8.150396752171218e-05,8.624045585747808e-05,9.095852874452248e-05,9.565630898578092e-05,0.0001003318902803585,0.00010498336632736027,0.00010960887448163703,0.00011420651571825147,0.00011877439828822389,0.00012331065954640508,0.0001278134441236034,0.0001322808675467968,0.00013671108172275126,0.000141102253110148,0.00014545254816766828,0.0001497601333539933,0.0001540231896797195,0.00015823989815544337,0.00016240851255133748,0.00016652722842991352,0.00017059428500942886,0.00017460795061197132,0.0001785664790077135,0.000182468123966828,0.000186311241122894,0.00019009409879799932,0.00019381505262572318,0.00019747245823964477,0.00020106470037717372,0.00020459013467188925,0.00020804721862077713,0.0002114343806169927,0.00021475004905369133,0.00021799272508360445,0.00022116090985946357,0.00022425313363783062,0.0002272679703310132,0.0002302039647474885,0.00023305974900722504,0.00023583396978210658,0.00023852525919210166,0.00024113230756483972,0.0002436538488836959,0.00024608863168396056,0.0002484354190528393,0.0002506930031813681,0.0002528602781239897,0.0002549360506236553,0.00025691924383863807,0.0002588088682387024,0.00026060373056679964,0.00026230295770801604,0.00026390558923594654,0.0002654106356203556,0.0002668171946424991,0.0002681245096027851,0.0002693316200748086,0.0002704378275666386,0.00027144240448251367,0.00027234453591518104,0.0002731436106842011,0.0002738390467129648,0.0002744301746133715,0.0002749163832049817,0.0002752972941379994,0.00027557232533581555,0.00027574104024097323,0.000275803089607507,0.0002757580659817904,0.00027560567832551897,0.0002753456064965576,0.0002749776467680931,0.00027450162451714277,0.0002739173360168934,0.0002732246939558536,0.000272423611022532,0.0002715140872169286,0.0002704961225390434,0.0002693697460927069,0.0002681350742932409,0.00026679225265979767,0.00026534145581535995,0.0002637829165905714,0.00026211689691990614,0.00026034374604932964,0.000258463725913316,0.0002564772730693221,0.0002543848822824657,0.0002521869901102036,0.00024988409131765366,0.0002474767970852554,0.0002449657185934484,0.00024235149612650275,0.00023963481362443417,0.00023681639868300408,0.00023389705165755004,0.0002308775729034096,0.0002277588500874117,0.00022454175632447004,0.0002212272520409897,0.0002178163267672062,0.00021430998458527029,0.00021070930233690888,0.00020701538596767932,0.00020322937052696943,0.0001993524783756584,0.00019538590277079493,0.00019133088062517345,0.00018718877981882542,0.00018296086636837572,0.00017864856636151671,0.00017425327678211033,0.00016977646737359464,0.00016521959332749248,0.00016058419714681804,0.00015587183588650078,0.00015108408115338534,0.000146222606417723,0.00014128899783827364,0.00013628504530061036,0.0001312124077230692,0.00012607284588739276,0.00012086817878298461,0.00011560021084733307,0.00011027079744962975,0.00010488183761481196,9.943520853994414e-05,9.393286745762452e-05,8.837679342832416e-05,8.27689582365565e-05,7.71113918744959e-05,7.140613888623193e-05,6.565527291968465e-05,5.986087489873171e-05,5.402508395491168e-05,4.815002830582671e-05,4.223787254886702e-05,3.629081038525328e-05,3.0311031878227368e-05,2.4300772565766238e-05,1.8262266166857444e-05,1.2197783689771313e-05,6.109595688030822e-06,-3.0534379695659953e-19,-6.128694167273352e-06,-1.2274163054826204e-05,-1.8434067897032946e-05,-2.4606057195342146e-05,-3.0787767173023894e-05,-3.6976824048906565e-05,-4.31708394899033e-05,-4.936742698191665e-05,-5.5564185458933935e-05,-6.175869202706963e-05,-6.794854562031105e-05,-7.413130515487865e-05,-8.030456956475973e-05,-8.646588685223833e-05,-9.261283412342891e-05,-9.874296665657312e-05,-0.00010485385428182781,-0.00011094305955339223,-0.00011700814502546564,-0.0001230466878041625,-0.00012905623589176685,-0.00013503436639439315,-0.00014097867824602872,-0.00014688671217299998,-0.00015275611076503992,-0.0001585844438523054,-0.00016436929581686854,-0.00017010830924846232,-0.00017579911218490452,-0.0001814393326640129,-0.00018702659872360528,-0.00019255861116107553,-0.00019803305622190237,-0.00020344756194390357,-0.00020879988733213395,-0.00021408773318398744,-0.00021930885850451887,-0.00022446100774686784,-0.00022954196901991963,-0.00023454957408830523,-0.00023948162561282516,-0.0002443359699100256,-0.0002491104824002832,-0.0002538030385039747,-0.0002584115427453071,-0.00026293404516763985,-0.00026736839208751917,-0.0002717126626521349,-0.0002759648486971855,-0.00028012305847369134,-0.0002841853420250118,-0.00028814980760216713,-0.00029201467987149954,-0.00029577803798019886,-0.0002994382521137595,-0.0003029934305232018,-0.00030644191429018974,-0.00030978210270404816,-0.00031301224953494966,-0.0003161308413837105,-0.00031913627753965557,-0.0003220270446036011,-0.00032480168738402426,-0.0003274586924817413,-0.0003299967502243817,-0.0003324144927319139,-0.00033471055212430656,-0.00033688367693684995,-0.00033893270301632583,-0.0003408563497941941,-0.0003426535113248974,-0.0003443231398705393,-0.0003458641585893929,-0.0003472756070550531,-0.00034855646663345397,-0.0003497058351058513,-0.0003507229557726532,-0.0003516068682074547,-0.00035235699033364654,-0.000352972507243976,-0.00035345274955034256,-0.00035379716427996755,-0.0003540051693562418,-0.0003540762700140476,-0.0003540100296959281,-0.0003538060118444264,-0.00035346386721357703,-0.0003529833338689059,-0.00035236412077210844,-0.00035160614061169326,-0.0003507091023493558,-0.000349673064192757,-0.000348497909726575,-0.0003471837262623012,-0.0003457305137999356,-0.0003441384469624609,-0.0003424077294766903,-0.0003405385941732675,-0.000338531332090497,-0.00033638632157817483,-0.00033410394098609686,-0.0003316845977678895,-0.00032912890310399234,-0.00032643740996718407,-0.00032361067133024335,-0.00032064938568510115,-0.0003175543970428407,-0.00031432631658390164,-0.00031096613383851945,-0.0003074746928177774,-0.0003038529248442501,-0.00030010181944817305,-0.0002962225116789341,-0.00029221599106676877,-0.00028808353818021715,-0.0002838262589648366,-0.0002794455213006586,-0.00027494257665239275,-0.00027031879290007055,-0.0002655756543390453,-0.0002607145579531789,-0.000255737075349316,-0.0002506447781343013,-0.00024543923791497946,-0.00024012218636926264,-0.00023469531151931733,-0.00022916035959497094,-0.00022351917868945748,-0.00021777361689601094,-0.0002119256096193567,-0.00020597706316038966,-0.00019993001478724182,-0.00019378647266421467,-0.00018754854681901634,-0.0001812183763831854,-0.0001747981004882604,-0.0001682899601291865,-0.00016169619630090892,-0.0001550191082060337,-0.0001482610241509974,-0.00014142433064989746,-0.00013451142876874655,-0.00012752476322930306,-0.00012046682240907103,-0.00011334013834130019,-0.0001061472503351979,-9.889074135571718e-05,-9.157324529951438e-05,-8.419739606324583e-05,-7.676590030314401e-05,-6.928145012352616e-05,-6.174680311232805e-05,-5.416471685748547e-05,-4.653798896470107e-05,-3.886945341946557e-05,-3.116194056929089e-05,-2.3418337150360458e-05,-1.56415317178471e-05,-7.834440111764707e-06,3.42602027998731e-19,7.858832759666257e-06,1.5739082300569862e-05,2.363775456615258e-05,3.155184458591975e-05,3.947832010453567e-05,4.741414522868581e-05,5.535627497010864e-05,6.330163887469098e-05,7.124716648831964e-05,7.918976189102978e-05,8.71263473527506e-05,9.505381603958085e-05,0.00010296906839357689,0.00011086898302892223,0.000118750445835758,0.00012661036453209817,0.00013444559590425342,0.00014225300401449203,0.00015002951840870082,0.00015777199587319046,0.00016547735140193254,0.00017314244178123772,0.0001807641820050776,0.0001883394579635933,0.0001958652283065021,0.00020333840802777559,0.0002107558975694701,0.0002181146846851334,0.00022541169892065227,0.00023264392802957445,0.00023980835976544768,0.0002469019964337349,0.00025392192765139043,0.00026086511206813157,0.0002677286684047431,0.0002745096280705184,0.00028120516799390316,0.0002878124068956822,0.0002943284634966403,0.0003007505729328841,0.0003070759412366897,0.00031330177444033325,0.00031942539499141276,0.00032544409623369575,0.0003313552006147802,0.000337156088789925,0.00034284417051821947,0.000348416855558753,0.0003538716700859368,0.00035920608206652105,0.00036441764677874744,0.00036950400681234896,0.0003744628047570586,0.0003792916249949485,0.0003839882556349039,0.0003885504265781492,0.0003929760423488915,0.0003972628037445247,0.0004014087899122387,0.0004054117889609188,0.0004092699382454157,0.000412981171393767,0.00041654365486465394,0.00041995549690909684,0.00042321498040109873,0.0004263203009031713,0.00042926977039314806,0.00043206175905652344,0.0004346947534941137,0.00043716715299524367,0.000439477531472221,0.0004416244919411838,0.00044360666652210057,0.00044542280375026166,0.00044707165216095746,0.0004485520184971392,0.00044986288412474096,0.00045100314309820533,0.0004519718640949577,0.00045276808668859303,0.00045339096686802804,0.0004538397479336709,0.0004541137022897601,0.00045421210234053433,0.0004541344824247062,0.0004538802895694971,0.00045344902900978923,0.0004528402932919562,0.0004520537913776934,0.00045108929043635726,0.0004499465867411345,0.0004486255347728729,0.000447126105427742,0.0004454483569134027,0.00044359234743751585,0.0004415582225192338,0.00043934627319686115,0.00043695670319721103,0.00043438997818157077,0.00043164644739590585,0.00042872666381299496,0.0004256312095094472,0.0004223606956657022,0.00041891587898135185,0.00041529754525981843,0.0004115065385121852,0.00040754376095719635,0.00040341023122891784,0.00039910702616907656,0.0003946352517232299,0.000389996130252257,0.00038519094232469797,0.0003802209976129234,0.0003750877222046256,0.0003697925712913275,0.0003643370873760432,0.0003587229293771088,0.00035295169800519943,0.0003470251976978034,0.00034094517468474805,0.00033471357892267406,0.00032833227305673063,0.0003218033234588802,0.00031512873829342425,0.0003083106130361557,0.0003013512468896806,0.0002942528226412833,0.00028701763949356973,0.0002796481130644679,0.00027214662986807525,0.0002645157219376415,0.0002567578630987555,0.00024887576000764966,0.00024087201745714992,0.00023274935665540397,0.0002245105424663052,0.0002161583979614079,0.0002076958044199273,0.00019912571588065475,0.00019045108638238162,0.0001816749427234754,0.0001728003699099645,0.00016383051115553826,0.00015476852422580123,0.00014561761054210365,0.00013638105883728713,0.0001270621723961085,0.00011766428360715508,0.0001081907976185903,9.864514868240803e-05,8.903079287847504e-05,7.935124449431896e-05,6.96100396453403e-05,5.9810769016621634e-05,4.99570305692032e-05,4.00524731958285e-05,3.01007730740821e-05,2.0105633666389622e-05,1.0070788448501844e-05,-3.7749896858475327e-19,-1.0102946362167131e-05,-2.0234238036209717e-05,-3.039004332094919e-05,-4.056650504935533e-05,-5.075974331703037e-05,-6.096587094361894e-05,-7.11809698259458e-05,-8.140111458487809e-05,-9.162236528936774e-05,-0.00010184076381847262,-0.00011205233749933541,-0.00012225312821101397,-0.00013243910507299006,-0.00014260632451623678,-0.00015275078476406634,-0.00016286845493596047,-0.00017295536235906184,-0.00018300746160093695,-0.0001930207945406437,-0.00020299131574574858,-0.0002129150670953095,-0.0002227880322607234,-0.00023260622401721776,-0.00024236566969193518,-0.0002520624257158488,-0.0002616924757603556,-0.00027125191991217434,-0.0002807368291541934,-0.0002901432744693011,-0.00029946735594421625,-0.000308705260977149,-0.00031785303144715726,-0.00032690694206394255,-0.00033586312201805413,-0.00034471775870770216,-0.0003534671850502491,-0.00036210755934007466,-0.0003706353309098631,-0.00037904668715782464,-0.00038733816472813487,-0.00039550598012283444,-0.000403546669986099,-0.00041145674185827374,-0.00041923264507204294,-0.00042687097447924316,-0.0004343682958278805,-0.0004417212912812829,-0.0004489265847951174,-0.00045598100405186415,-0.0004628812603186816,-0.00046962418127804995,-0.0004762066528201103,-0.0004826256772503257,-0.0004888781113550067,-0.0004949611029587686,-0.0005008716834709048,-0.0005066070589236915,-0.0005121644353494048,-0.0005175410769879818,-0.0005227342480793595,-0.0005277413874864578,-0.0005325599922798574,-0.000537187559530139,-0.0005416216445155442,-0.0005458599771372974,-0.0005499001126736403,-0.0005537400720641017,-0.0005573775270022452,-0.0005608105566352606,-0.000564037065487355,-0.0005670552491210401,-0.000569863012060523,-0.00057245884090662,-0.0005748409312218428,-0.0005770076531916857,-0.000578957493416965,-0.000580688938498497,-0.0005822006496600807,-0.0005834914045408368,-0.0005845598061569035,-0.0005854047485627234,-0.0005860253586433828,-0.0005864204140380025,-0.0005865891580469906,-0.0005865307757630944,-0.0005862445686943829,-0.0005857297801412642,-0.000584985944442451,-0.000584012595936656,-0.0005828093271702528,-0.0005813759053125978,-0.0005797120393253863,-0.0005778177874162793,-0.0005756928585469723,-0.0005733374855481088,-0.0005707518430426717,-0.0005679360474459827,-0.0005648905062116683,-0.0005616156267933547,-0.0005581119912676513,-0.0005543800652958453,-0.0005504206637851894,-0.0005462344852276146,-0.0005418224609456956,-0.0005371854640543461,-0.0005323245422914624,-0.0005272408598102629,-0.0005219356971792877,-0.0005164103349670768,-0.0005106662283651531,-0.0005047047743573785,-0.0004985276609659195,-0.0004921364015899599,-0.0004855329461861402,-0.00047871898277662694,-0.0004716965777333826,-0.0004644676810130477,-0.00045703438809141517,-0.00044939893996343017,-0.0004415636067278683,-0.0004335306875873357,-0.0004253026854712516,-0.00041688213241286576,-0.0004082716186530888,-0.00039947385084815323,-0.0003904915938619524,-0.00038132769986987114,-0.00037198513746261597,-0.0003624668752308935,-0.00035277599818073213,-0.0003429157368373126,-0.0003328892635181546,-0.00032269995426759124,-0.0003123511269222945,-0.0003018463321495801,-0.0002911890624091029,-0.00028038289747200906,-0.000269431562628597,-0.0002583388122729957,-0.0002471083716955036,-0.00023574416991323233,-0.00022425016504712403,-0.00021263034432195127,-0.00020088876772206277,-0.00018902953888755292,-0.0001770569069776684,-0.000164975062943995,-0.00015278832870535553,-0.00014050101162865758,-0.0001281175937037915,-0.00011564247688511387,-0.00010308017954230309,-9.043527825269848e-05,-7.771235686959699e-05,-6.49160792818293e-05,-5.205113484407775e-05,-3.912226020474918e-05,-2.6134230211027898e-05,-1.309185699938098e-05,4.0899536967257005e-19,1.3136455891071819e-05,2.631258757901378e-05,3.9523445593658835e-05,5.276403680909425e-05,6.602936628041789e-05,7.931436994113028e-05,9.261401282856241e-05,0.00010592319449642673,0.00011923679994652048,0.0001325497287325561,0.00014585680037271231,0.00015915289986878633,0.0001724328176351264,0.00018569137318991125,0.00019892341515515,0.00021212370484136045,0.00022528704721480608,0.00023840824724175036,0.0002514820662327111,0.0002645032946020365,0.00027746675186790526,0.00029036725754849613,0.00030319951474666595,0.0003159584302920848,0.0003286388237029314,0.0003412354562897235,0.0003537432348821312,0.00036615700810216367,0.0003784716536756605,0.0003906821075361222,0.0004027832474093884,0.00041477003833279014,0.0004266374744474888,0.00043838057899847627,0.00044999431702308357,0.00046147379907779396,0.0004728141939267516,0.00048401058302260935,0.0004950580769218504,0.0005059519899077713,0.0005166875780560076,0.0005272600683383644,0.0005376649205572903,0.0005478974198922515,0.0005579530843533576,0.0005678274319507182,0.000577515980694443,0.0005870143650099635,0.0005963182775303721,0.0006054233526811004,0.0006143254577182233,0.0006230204598978162,0.0006315042264759541,0.0006397727993316948,0.0006478221039287746,0.0006556484149768949,0.0006632478907704353,0.0006706166896037757,0.0006777513190172613,0.0006846481701359153,0.0006913036340847611,0.0006977143348194659,0.0007038770127110183,0.0007097883499227464,0.0007154451450332999,0.0007208444294519722,0.0007259830599650741,0.0007308581843972206,0.000735467066988349,0.0007398068555630744,0.0007438750471919775,0.0007476689643226564,0.0007511863368563354,0.0007544246618635952,0.0007573817274533212,0.0007600554963573813,0.0007624438730999827,0.0007645449368283153,0.0007663567084819078,0.0007678776164539158,0.0007691059727221727,0.0007700402638874948,0.0007706790347583592,0.0007710210047662258,0.0007710650097578764,0.0007708098855800927,0.0007702547009103,0.0007693985826335847,0.0007682408322580159,0.0007667806930840015,0.0007650177576579154,0.0007629515021108091,0.0007605816936120391,0.0007579081575386226,0.0007549307192675769,0.0007516496116295457,0.0007480647182092071,0.0007441765628755093,0.0007399854948744178,0.0007354919798672199,0.0007306966581381857,0.0007256002281792462,0.0007202036213129759,0.0007145078852772713,0.000708513951394707,0.0007022232166491449,0.0006956368451938033,0.0006887564086355269,0.0006815834203734994,0.0006741196266375482,0.0006663668318651617,0.000658326898701489,0.000650001922622323,0.0006413940573111176,0.0006325055146589875,0.000623338739387691,0.0006138962344266474,0.0006041805609129369,0.0005941945710219443,0.0005839409423060715,0.000573422817979008,0.0005626431084237993,0.0005516050732694566,0.0005403119721449912,0.0005287672393023968,0.0005169743672013283,0.0005049369647167623,0.0004926587571389973,0.0004801435861736536,0.0004673953226301819,0.0004544180992525071,0.0004412159905768931,0.00042779321665875614,0.00041415420128032565,0.0004003032809123397,0.00038624508306384087,0.0003719841770362109,0.0003575253067538142,0.0003428732743486762,0.00032803299836814404,0.00031300951377488673,0.00029780788463540375,0.0002824332914315164,0.000266890914645046,0.00025118625489994884,0.0002353245799895376,0.00021931150695309043,0.0002031525655183941,0.0001868534309323877,0.00017041985120158643,0.00015385760343633592,0.00013717258116230369,0.00012037075066473335,0.00010345811460865662,8.644074114272371e-05,6.932477845111862e-05,5.2116440201643854e-05,3.4821972803911194e-05,1.744770270306617e-05,-4.361531567487579e-19,-1.751470881572459e-05,-3.508994996082038e-05,-5.2719198720296845e-05,-7.03958939993754e-05,-8.811341831460595e-05,-0.00010586513235466555,-0.0001236443204106763,-0.00014144428132567555,-0.00015925827028695494,-0.00017707944789435714,-0.00019490103295538574,-0.0002127161860698834,-0.00023051799507811666,-0.00024829962057992816,-0.000266054121311754,-0.00028377457056194544,-0.0003014540416188538,-0.00031908557866699994,-0.00033666222589090466,-0.00035417702747508883,-0.00037162299850024283,-0.0003889931831508875,-0.0004062805965077132,-0.00042347825365141034,-0.00044057925697416067,-0.00045757662155665457,-0.0004744634497910738,-0.0004912327858619392,-0.0005078777321614325,-0.000524391420185566,-0.0005407669814303517,-0.000556997605599463,-0.0005730764241889119,-0.0005889967433176935,-0.0006047518108971417,-0.0006203348748385906,-0.0006357392994686961,-0.000650958449114114,-0.0006659857463091612,-0.0006808146717958152,-0.0006954387645237148,-0.0007098516216501594,-0.0007240466657094657,-0.0007380178431048989,-0.0007517587509937584,-0.0007652631611563265,-0.0007785249617882073,-0.0007915382739156485,-0.0008042968111112714,-0.0008167948690243065,-0.0008290265686810017,-0.0008409860311076045,-0.0008526676683686674,-0.0008640658343210816,-0.0008751749992370605,-0.0008859898080118,-0.0008965047891251743,-0.000906714762095362,-0.0009166145464405417,-0.0009261990780942142,-0.0009354633511975408,-0.0009444026509299874,-0.0009530121460556984,-0.0009612870635464787,-0.00096922303782776,-0.0009768155869096518,-0.0009840602288022637,-0.000990952947176993,-0.0009974895510822535,-0.0010036661988124251,-0.001009478815831244,-0.0010149237932637334,-0.0010199975222349167,-0.0010246963938698173,-0.0010290172649547458,-0.0010329567594453692,-0.0010365118505433202,-0.001039679511450231,-0.0010424568317830563,-0.0010448413668200374,-0.0010468303225934505,-0.0010484213707968593,-0.001049612183123827,-0.0010504006640985608,-0.0010507848346605897,-0.0010507628321647644,-0.0010503330267965794,-0.0010494935559108853,-0.001048243255354464,-0.0010465809609740973,-0.001044505275785923,-0.0010420155012980103,-0.0010391105897724628,-0.001035790191963315,-0.0010320533765479922,-0.0010279002599418163,-0.0010233302600681782,-0.0010183434933423996,-0.0010129401925951242,-0.0010071205906569958,-0.0010008849203586578,-0.0009942339966073632,-0.000987168401479721,-0.000979689066298306,-0.000971797329839319,-0.0009634941234253347,-0.0009547809604555368,-0.0009456593543291092,-0.0009361310512758791,-0.0009261979139409959,-0.0009158618631772697,-0.0009051252854987979,-0.0008939904510043561,-0.0008824597462080419,-0.0008705360232852399,-0.0008582220179960132,-0.0008455207571387291,-0.0008324353257194161,-0.0008189690415747464,-0.0008051254553720355,-0.0007909081177785993,-0.0007763207540847361,-0.0007613673806190491,-0.0007460520719178021,-0.000730379018932581,-0.000714352645445615,-0.0006979774916544557,-0.0006812581559643149,-0.0006641996442340314,-0.000646806787699461,-0.0006290848832577467,-0.0006110391113907099,-0.0005926748854108155,-0.0005739978514611721,-0.0005550136556848884,-0.0005357281770557165,-0.0005161474691703916,-0.0004962775274179876,-0.0004761247255373746,-0.0004556954081635922,-0.00043499612365849316,-0.0004140335659030825,-0.0003928144578821957,-0.00037134578451514244,-0.00034963450161740184,-0.0003276877978350967,-0.00030551303643733263,-0.0002831175224855542,-0.00026050882297568023,-0.0002376945485593751,-0.0002146824263036251,-0.00019148032879456878,-0.0001680962013779208,-0.00014453809126280248,-0.00012081419117748737,-9.693273023003712e-05,-7.290209032362327e-05,-4.873070793109946e-05,-2.442713775963057e-05,4.581634505718166e-19,2.4541985112591647e-05,4.9190020945388824e-05,7.39352180971764e-05,9.876863623503596e-05,0.00012368122406769544,0.00014866390847600996,0.00017370747809763998,0.00019880273612216115,0.00022394036932382733,0.00024911100626923144,0.0002743052609730512,0.00029951363103464246,0.0003247266577091068,0.0003499347367323935,0.00037512826384045184,0.00040029757656157017,0.0004254330706316978,0.0004505249671638012,0.0004755635163746774,0.0005005389684811234,0.0005254415445961058,0.0005502614076249301,0.000574988778680563,0.0005996137042529881,0.000624126463662833,0.0006485171034000814,0.0006727758445776999,0.0006968927918933332,0.000720858050044626,0.0007446618983522058,0.0007682943250983953,0.0007917457260191441,0.0008150061476044357,0.0008380658691748977,0.0008609152282588184,0.0008835443877615035,0.0009059436852112412,0.000928103516343981,0.000950014335103333,0.0009716664208099246,0.0009930504020303488,0.0010141568491235375,0.001034976332448423,0.001055499422363937,0.0010757169220596552,0.0010956196347251534,0.0011151982471346855,0.0011344439117237926,0.0011533476645126939,0.001171900425106287,0.001190093462355435,0.0012079180451110005,0.001225365442223847,0.0012424273882061243,0.0012590950354933739,0.0012753602350130677,0.001291214837692678,0.0013066506944596767,0.0013216596562415361,0.0013362339232116938,0.0013503654627129436,0.001364047173410654,0.0013772710226476192,0.001390029676258564,0.0014023160329088569,0.0014141228748485446,0.0014254432171583176,0.0014362703077495098,0.0014465972781181335,0.0014564174925908446,0.0014657247811555862,0.001474512740969658,0.0014827754348516464,0.001490506692789495,0.001497700926847756,0.0015043524326756597,0.0015104558551684022,0.0015160058392211795,0.0015209974953904748,0.001525425584986806,0.0015292855678126216,0.0015325729036703706,0.0015352830523625016,0.0015374121721833944,0.0015389558393508196,0.0015399105614051223,0.0015402727294713259,0.0015400387346744537,0.0015392055502161384,0.0015377701492980123,0.0015357296215370297,0.0015330812893807888,0.0015298229409381747,0.0015259524807333946,0.0015214676968753338,0.0015163668431341648,0.0015106482896953821,0.001504311105236411,0.001497353776358068,0.0014897753717377782,0.0014815755421295762,0.0014727534726262093,0.0014633092796429992,0.0014532427303493023,0.0014425539411604404,0.0014312434941530228,0.0014193120878189802,0.0014067604206502438,0.0013935897732153535,0.0013798015424981713,0.0013653971254825592,0.0013503785012289882,0.0013347474159672856,0.0013185065472498536,0.0013016581069678068,0.001284204889088869,0.001266149920411408,0.0012474963441491127,0.0012282476527616382,0.0012084073387086391,0.0011879794765263796,0.0011669682571664453,0.001145377871580422,0.0011232129763811827,0.0011004784610122442,0.0010771792149171233,0.0010533208260312676,0.0010289084166288376,0.0010039480403065681,0.0009784456342458725,0.0009524073102511466,0.0009258395875804126,0.0008987490436993539,0.0008711426635272801,0.0008430274901911616,0.0008144108578562737,0.0007853003335185349,0.0007557037170045078,0.0007256289827637374,0.0006950843380764127,0.000664078164845705,0.0006326191942207515,0.0006007162155583501,0.0005683783092536032,0.000535614846739918,0.0005024350830353796,0.00046884885523468256,0.00043486602953635156,0.0004004966758657247,0.00036575106787495315,0.00033063971204683185,0.0002951732312794775,0.0002593625395093113,0.00022321863798424602,0.0001867527753347531,0.00014997638936620206,0.00011290105612715706,7.553855539299548e-05,3.7900827010162175e-05,-4.743707105062978e-19,-3.815164745901711e-05,-7.654167711734772e-05,-0.00011515745427459478,-0.00015398621326312423,-0.0001930150465341285,-0.0002322308428119868,-0.00027162046171724796,-0.0003111703845206648,-0.00035086722346022725,-0.0003906972997356206,-0.0004306468181312084,-0.0004707018961198628,-0.0005108484183438122,-0.0005510722985491157,-0.0005913592758588493,-0.0006316948565654457,-0.0006720646633766592,-0.0007124539697542787,-0.000752848107367754,-0.0007932322332635522,-0.0008335914462804794,-0.0008739108452573419,-0.000914175296202302,-0.0009543695487082005,-0.0009944784687831998,-0.0010344866896048188,-0.0010743788443505764,-0.0011141394497826695,-0.0011537530226632953,-0.0011932040797546506,-0.0012324769049882889,-0.0012715558987110853,-0.0013104253448545933,-0.0013490695273503661,-0.0013874727301299572,-0.001425619120709598,-0.0014634927501901984,-0.0015010781353339553,-0.0015383590944111347,-0.001575320027768612,-0.0016119448700919747,-0.0016482179053127766,-0.0016841231845319271,-0.0017196449916809797,-0.0017547676106914878,-0.0017894749762490392,-0.001823751605115831,-0.0018575816648080945,-0.0018909494392573833,-0.0019238392123952508,-0.001956235384568572,-0.0019881227053701878,-0.0020194852259010077,-0.0020503078121691942,-0.0020805750973522663,-0.002110271481797099,-0.0021393822971731424,-0.002167891710996628,-0.0021957852877676487,-0.0022230478934943676,-0.0022496646270155907,-0.0022756203543394804,-0.0023009011056274176,-0.0023254919797182083,-0.0023493783082813025,-0.0023725461214780807,-0.002394981449469924,-0.002416669623926282,-0.0024375971406698227,-0.0024577504955232143,-0.0024771152529865503,-0.002495678374543786,-0.0025134270545095205,-0.0025303468573838472,-0.002546426374465227,-0.0025616514030843973,-0.002576009836047888,-0.002589489333331585,-0.0026020773220807314,-0.002613761695101857,-0.002624530578032136,-0.0026343720965087414,-0.0026432753074914217,-0.0026512283366173506,-0.002658219775184989,-0.002664239378646016,-0.0026692759711295366,-0.0026733195409178734,-0.0026763593778014183,-0.0026783854700624943,-0.002679388504475355,-0.00267935823649168,-0.0026782858185470104,-0.0026761621702462435,-0.002672977978363633,-0.0026687253266572952,-0.0026633956003934145,-0.0026569801848381758,-0.002649471862241626,-0.0026408631820231676,-0.0026311464607715607,-0.002620314946398139,-0.002608361653983593,-0.0025952800642699003,-0.0025810645893216133,-0.002565708477050066,-0.0025492068380117416,-0.002531553851440549,-0.002512744627892971,-0.002492774510756135,-0.0024716388434171677,-0.0024493334349244833,-0.0024258545599877834,-0.002401198958978057,-0.002375362440943718,-0.0023483429104089737,-0.002320137806236744,-0.0022907438687980175,-0.002260159933939576,-0.0022283841390162706,-0.0021954146213829517,-0.0021612506825476885,-0.00212589162401855,-0.0020893369801342487,-0.002051586052402854,-0.002012640004977584,-0.001972498372197151,-0.0019311626674607396,-0.0018886339385062456,-0.0018449135823175311,-0.0018000033451244235,-0.0017539055552333593,-0.0017066225409507751,-0.0016581573290750384,-0.001608512713573873,-0.0015576924197375774,-0.0015057000564411283,-0.001452539931051433,-0.0013982162345200777,-0.0013427339727059007,-0.0012860980350524187,-0.0012283140094950795,-0.0011693876003846526,-0.0011093249777331948,-0.0010481324279680848,-0.0009858165867626667,-0.0009223847882822156,-0.0008578442502766848,-0.0007922026561573148,-0.0007254680385813117,-0.0006576487794518471,-0.0005887536099180579,-0.0005187913193367422,-0.0004477713955566287,-0.0003757033555302769,-0.0003025971818715334,-0.0002284630318172276,-0.000153311513713561,-7.715344690950587e-05,4.842922766647768e-19,7.813736738171428e-05,0.00015724690456409007,0.00023731654800940305,0.0003183339140377939,0.00040028642979450524,0.00048316107131540775,0.0005669446545653045,0.0006516237044706941,0.0007371843094006181,0.0008236125577241182,0.000910894013941288,0.0009990140097215772,0.0010879577603191137,0.0011777100153267384,0.001268255291506648,0.0013595782220363617,0.0014516625087708235,0.001544492319226265,0.0016380507731810212,0.0017323214560747147,0.0018272874876856804,0.0019229315221309662,0.0020192365627735853,0.002116184448823333,0.0022137577179819345,0.0023119382094591856,0.0024107075296342373,0.002510047284886241,0.0026099388487637043,0.0027103631291538477,0.002811300801113248,0.002912733471021056,0.0030146408826112747,0.0031170034781098366,0.003219801699742675,0.0033230152912437916,0.003426623996347189,0.003530607558786869,0.003634945722296834,0.003739617532119155,0.003844602033495903,0.003949879202991724,0.0040554264560341835,0.004161223769187927,0.0042672487907111645,0.004373481031507254,0.004479898605495691,0.004586479626595974,0.0046932026743888855,0.004800045397132635,0.004906985908746719,0.0050140018574893475,0.0051210722886025906,0.005228173453360796,0.00533528346568346,0.00544238043949008,0.005549441557377577,0.00565644446760416,0.0057633668184280396,0.0058701857924461365,0.005976878572255373,0.006083422806113958,0.0061897956766188145,0.0062959748320281506,0.0064019374549388885,0.006507660262286663,0.006613121367990971,0.006718297488987446,0.006823166273534298,0.006927705369889736,0.007031891494989395,0.007135702297091484,0.007239115424454212,0.007342108059674501,0.007444657851010561,0.0075467424467206,0.007648339495062828,0.007749426178634167,0.0078499810770154,0.007949982769787312,0.008049406111240387,0.008148232474923134,0.008246438577771187,0.00834400299936533,0.008440903387963772,0.008537118323147297,0.008632626384496689,0.00872740801423788,0.008821440860629082,0.008914702571928501,0.009007173590362072,0.009098833426833153,0.009189660660922527,0.009279636666178703,0.00936873909085989,0.00945694837719202,0.009544244036078453,0.009630609303712845,0.00971602089703083,0.009800462052226067,0.009883913211524487,0.009966352954506874,0.010047766380012035,0.010128132998943329,0.010207434184849262,0.010285652242600918,0.010362770408391953,0.010438770055770874,0.01051363255828619,0.010587343946099281,0.010659884661436081,0.01073123887181282,0.010801391676068306,0.010870324447751045,0.010938023217022419,0.011004472151398659,0.011069654487073421,0.011133556254208088,0.011196164414286613,0.011257462203502655,0.011317437514662743,0.011376073583960533,0.011433359235525131,0.011489280499517918,0.011543825268745422,0.011596979573369026,0.011648731306195259,0.011699069291353226,0.011747981421649456,0.01179545745253563,0.011841483414173126,0.01188605278730]'
    type: fcc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: QAM_Freq
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: I Spectrum
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: carrier_freq
    fftsize: '1024'
    name: Q_Spectrum
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: QAM_Time
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: I Waweform
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: Q waveform
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '5'
    ymin: '-5'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.1'
    decim: '1'
    gain: '32'
    ntaps: '321'
    samp_rate: samp_rate
    sym_rate: '1000'
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.1'
    decim: '1'
    gain: '32'
    ntaps: '321'
    samp_rate: samp_rate
    sym_rate: '1000'
    type: fir_filter_ccf
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_char_to_float_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_char_to_float_0_0, '0', interp_fir_filter_xxx_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_sub_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_pack_k_bits_bb_0, '0', digital_map_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_map_bb_0_0, '0']
- [blocks_sub_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_0_0, '0']
- [interp_fir_filter_xxx_0, '0', root_raised_cosine_filter_0, '0']
- [interp_fir_filter_xxx_0_0, '0', root_raised_cosine_filter_0_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_multiply_xx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_1, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_multiply_xx_0_0, '1']
- [root_raised_cosine_filter_0_0, '0', qtgui_freq_sink_x_1_0, '0']
- [root_raised_cosine_filter_0_0, '0', qtgui_time_sink_x_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
